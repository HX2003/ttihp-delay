** sch_path: tile_simulation/tile_test.sch
**.subckt tile_test
V2 VDD GND PWL(0ns 0 0.1ns 1.2)
V4 dll_rst_n GND PWL(0ns 0 300ns 0 300.1ns 1.2)
V1 REF_CLK GND PULSE(0 1.2 0n 100p 100p 10ns 20ns)
V3 TEST_SIGNAL_IN GND PULSE(0 1.2 0n 100p 100p 20ns 100ns)
V5 STIMULUS_clk GND PWL(0.0n 0 20.0n 0 20.1n 1.2 40.0n 1.2 40.1n 0 80.0n 0 80.1n 1.2 100.0n 1.2
+ 100.1n 0 140.0n 0 140.1n 1.2 160.0n 1.2 160.1n 0 200.0n 0 200.1n 1.2 220.0n 1.2 220.1n 0 260.0n 0 260.1n
+ 1.2 280.0n 1.2 280.1n 0 320.0n 0 320.1n 1.2 340.0n 1.2 340.1n 0 360.0n 0)
V6 STIMULUS_reg_addr0 GND PWL(0.0n 0 120.0n 0 120.1n 1.2 180.0n 1.2 180.1n 0 240.0n 0 240.1n 1.2
+ 300.0n 1.2 300.1n 0 360.0n 0)
V7 STIMULUS_reg_addr1 GND PWL(0.0n 0 180.0n 0 180.1n 1.2 300.0n 1.2 300.1n 0 360.0n 0)
V8 STIMULUS_reg_addr2 GND PWL(0.0n 0 300.0n 0 300.1n 1.2 360.0n 1.2)
V9 STIMULUS_reg_val0 GND PWL(0.0n 0 180.0n 0 180.1n 1.2 240.0n 1.2 240.1n 0 300.0n 0 300.1n 1.2
+ 360.0n 1.2)
V10 STIMULUS_reg_val1 GND PWL(0.0n 0 60.0n 0 60.1n 1.2 360.0n 1.2)
V11 STIMULUS_reg_val2 GND PWL(0.0n 0 120.0n 0 120.1n 1.2 240.0n 1.2 240.1n 0 300.0n 0 300.1n 1.2
+ 360.0n 1.2)
V12 STIMULUS_reg_val3 GND PWL(0.0n 0 300.0n 0 300.1n 1.2 360.0n 1.2)
V13 STIMULUS_reg_val4 GND PWL(0.0n 0 240.0n 0 240.1n 1.2 360.0n 1.2)
V14 STIMULUS_rst_n GND PWL(0.0n 0 60.0n 0 60.1n 1.2 360.0n 1.2)
x1 GND VDD STIMULUS_clk VDD STIMULUS_rst_n TEST_SIGNAL_IN TEST_SIGNAL_IN TEST_SIGNAL_IN
+ TEST_SIGNAL_IN REF_CLK dll_rst_n GND GND STIMULUS_reg_addr0 STIMULUS_reg_addr1 STIMULUS_reg_addr2
+ STIMULUS_reg_val0 STIMULUS_reg_val1 STIMULUS_reg_val2 STIMULUS_reg_val3 STIMULUS_reg_val4 net5 net7 net9 net11 net13
+ net15 net17 net19 net4 net6 net8 net10 net12 net14 net16 net18 TEST_SIGNAL_OUT0 TEST_SIGNAL_OUT1
+ TEST_SIGNAL_OUT2 TEST_SIGNAL_OUT3 REF_CLK_OUT net1 net2 net3 tt_um_hx2003_delay
**** begin user architecture code






* Note! Since this script is wrapped in tcleval,
* code that is written in square brackets are in TCL scripting language
*
* The rest of the code is in spice scripting language

* Disabled because of computational cost/memory usage for big designs
* Save FET params like ids, gm, gds, vth, vgs, vdss, vds, cgg, cgsol, cgdol
* for annotation later (easier debugging and analysis)
* .include [file rootname [file tail [xschem get current_name]]].save

.options temp=25


[set prefix ".include "
set middle [xschem get current_dirname]
set suffix /tt_um_hx2003_delay.pex.spice
return $prefix$middle$suffix]


.control
  * save all is not suitable for large designs / long simulations
  * save all

  save v(VDD) v(dll_rst_n) v(REF_CLK) v(TEST_SIGNAL_IN)
  + v(TEST_SIGNAL_OUT0) v(TEST_SIGNAL_OUT1) v(TEST_SIGNAL_OUT2) v(TEST_SIGNAL_OUT3) v(REF_CLK_OUT)
  + v(STIMULUS_rst_n) + v(STIMULUS_clk)
  + v(STIMULUS_reg_addr0) + v(STIMULUS_reg_addr1) + v(STIMULUS_reg_addr2)
  + v(STIMULUS_reg_val0) + v(STIMULUS_reg_val1) + v(STIMULUS_reg_val2)
  + v(STIMULUS_reg_val3) + v(STIMULUS_reg_val4)

  * skip initial dc operating point calculations using uic
  * use 10p instead of 5p for faster simulation
  tran 10p 3000n uic

  write [file rootname [file tail [xschem get current_name]]].raw

  * I DID NOT USE THE BELOW, because if an error occured we wouldn't know
  * Automatically close the popup after simulation complete *
  * quit
.endc









.lib $::MODELS_NGSPICE/cornerMOSlv.lib mos_tt
.lib $::MODELS_NGSPICE/cornerRES.lib res_typ
.lib $::MODELS_NGSPICE/cornerCAP.lib cap_typ
*.include sg13g2_stdcell.spice



**** end user architecture code
**.ends
.GLOBAL GND
.end
