** sch_path: schematics/delay_line_with_mux_test.sch
**.subckt delay_line_with_mux_test
V2 VDD GND PWL(0ns 0 0.1ns 1.2)
R1 GND VSS 0.00001 m=1
Vmycc1 net1 net3 0
.save i(vmycc1)
XM36 net1 net1 VDD VDD sg13_lv_pmos w=1.12u l=0.6u ng=1 m=1 mm_ok=1
XM38 net3 net2 VSS VSS sg13_lv_nmos w=0.74u l=0.6u ng=1 m=1 mm_ok=1
V3 DELAY_IN VSS PULSE(0 1.2 60n 100p 100p 20ns 100ns)
V1 net2 VSS 0.49
x1 DELAY_OUT VSS VDD DELAY_IN net5 net4 MUX_OUT net8 net6 net7 net2 net1 hx_delay_line_with_mux
Vbit1 net4 VSS 1.2
Vbit2 net6 VSS 1.2
Vbit0 net5 VSS 1.2
Vbit3 net7 VSS 1.2
Vbit4 net8 VSS 1.2
**** begin user architecture code






* Note! Since this script is wrapped in tcleval,
* code that is written in square brackets are in TCL scripting language
*
* The rest of the code is in spice scripting language

.options temp=25

* Disabled because of computational cost for big designs
* Save FET params like ids, gm, gds, vth, vgs, vdss, vds, cgg, cgsol, cgdol
* for annotation later (easier debugging and analysis)
* .include [file rootname [file tail [xschem get current_name]]].save

[if {[info exists tcl_var_use_post_layout_netlist] && $tcl_var_use_post_layout_netlist == 1} {
  set prefix ".include "
  set middle [file dirname [xschem get current_dirname]]
  set suffix /build/spice_parasitics/hx_delay_line_with_mux.pex.spice
  return $prefix$middle$suffix
}]

* Configure how long to run the simulation for
* NGSpice also supports maxStep, but I did not use here
.csparam suggestedStep=50ps, tstop=120ns

.control
  * IMPORTANT: variable/vector names MUST not be the same as those in netlist
  * otherwise, weirdness occurs
  let do_multi_sim = true

  if do_multi_sim = true
    let high_val = 1.2
    let loop_cnt = 32
    * Initialize vectors to store results
    let indices = vector(loop_cnt)
    let tap_value = vector(loop_cnt)
    let delay_rising = vector(loop_cnt)
    let delay_falling = vector(loop_cnt)

    * Loop through 0 to 31 (5-bit patterns)
    let index = 0
    while index < loop_cnt
      let indices[index] = index

      * Set voltage sources to either 0 or vdd
      let bit0val = (index % 2) * high_val
      let bit1val = (floor(index / 2) % 2) * high_val
      let bit2val = (floor(index / 4) % 2) * high_val
      let bit3val = (floor(index / 8) % 2) * high_val
      let bit4val = (floor(index / 16) % 2) * high_val

      alter Vbit0 = $&bit0val
      alter Vbit1 = $&bit1val
      alter Vbit2 = $&bit2val
      alter Vbit3 = $&bit3val
      alter Vbit4 = $&bit4val

      * save all
      save DELAY_IN MUX_OUT
      tran $&suggestedStep $&tstop

      * Ignore the first 50ns, thus using TD=50ns
      * Half of supply 1.2V, is 0.6V, thus using VAL=0.6
      meas tran tdelay_rise TRIG v(DELAY_IN) VAL=0.6 TD=50ns RISE=1 TARG v(MUX_OUT) VAL=0.6 TD=40ns
+ RISE=1
      meas tran tdelay_fall TRIG v(DELAY_IN) VAL=0.6 TD=50ns FALL=1 TARG v(MUX_OUT) VAL=0.6 TD=40ns
+ FALL=1

      let delay_rising[index] = tdelay_rise
      let delay_falling[index] = tdelay_fall

      * write [file rootname [file tail [xschem get current_name]]].raw

      let index = index + 1
    end

    write [file rootname [file tail [xschem get current_name]]].raw delay_rising delay_falling
+ indices

    plot delay_rising vs indices delay_falling vs indices title 'Delay vs Tap value' xlabel 'Tap value (0-31)'
+ ylabel 'Delay (s)'
  else
    save all
    tran $&suggestedStep $&tstop
    write [file rootname [file tail [xschem get current_name]]].raw
  end

  * I DID NOT USE THE BELOW, because if an error occured we wouldn't know
  * Automatically close the popup after simulation complete *
  * quit
.endc









.lib $::MODELS_NGSPICE/cornerMOSlv.lib mos_tt
.lib $::MODELS_NGSPICE/cornerRES.lib res_typ
.lib $::MODELS_NGSPICE/cornerCAP.lib cap_typ
* Below has been commented, as standard cell schematics are used instead
* .include sg13g2_stdcell.spice



**** end user architecture code
**.ends
.GLOBAL GND
.end
