** sch_path: schematics/misc/inverter_delay_analysis.sch
**.subckt inverter_delay_analysis
XM12 sig2 net1 GND GND sg13_lv_nmos w=0.74u l=0.13u ng=1 m=1 mm_ok=1
XM15 sig2 net1 VDD VDD sg13_lv_pmos w=1.12u l=0.13u ng=1 m=1 mm_ok=1
XM16 sig3 sig2 GND GND sg13_lv_nmos w=0.74u l=0.13u ng=1 m=1 mm_ok=1
XM17 sig3 sig2 VDD VDD sg13_lv_pmos w=1.12u l=0.13u ng=1 m=1 mm_ok=1
V2 VDD GND PWL(0ns 0 0.1ns 1.2)
XM1 net2 sig3 GND GND sg13_lv_nmos w=0.74u l=0.13u ng=1 m=1 mm_ok=1
XM2 net2 sig3 VDD VDD sg13_lv_pmos w=1.12u l=0.13u ng=1 m=1 mm_ok=1
XM3 net3 net2 GND GND sg13_lv_nmos w=0.74u l=0.13u ng=1 m=1 mm_ok=1
XM4 net3 net2 VDD VDD sg13_lv_pmos w=1.12u l=0.13u ng=1 m=1 mm_ok=1
V1 net1 GND PWL(0ns 0 1ns 0 1.1ns 1.2)
**** begin user architecture code

  .lib $::MODELS_NGSPICE/cornerCAP.lib cap_typ
  .lib cornerMOSlv.lib mos_tt
  .lib cornerRES.lib res_typ



* Note! Since this script is wrapped in tcleval,
* code that is written in square brackets are in TCL scripting language
*
* The rest of the code is in spice scripting language

* Disabled because of computational cost/memory usage for big designs
* Save FET params like ids, gm, gds, vth, vgs, vdss, vds, cgg, cgsol, cgdol
* for annotation later (easier debugging and analysis)
.include [file rootname [file tail [xschem get current_name]]].save

* Customized code to include spice model for simulation

.include sg13g2_stdcell.spice
.options temp=25


.control
  save all

  tran 1p 2n

  write [file rootname [file tail [xschem get current_name]]].raw

  * I DID NOT USE THE BELOW, because if an error occured we wouldn't know
  * Automatically close the popup after simulation complete *
  * quit
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
