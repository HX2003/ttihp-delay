** sch_path: schematics/misc/bias_gen_res_dc_analysis.sch
**.subckt bias_gen_res_dc_analysis
Vdd VDD GND 3
Vmcur2 net1 net7 0
.save i(vmcur2)
XM1 net2 net1 VDD VDD sg13_lv_pmos w=4u l=1u ng=2 m=2 mm_ok=1
XM33 net1 net1 VDD VDD sg13_lv_pmos w=4u l=1u ng=2 m=2 mm_ok=1
Vmcur net2 net6 0
.save i(vmcur)
XM29 net3 net1 VDD VDD sg13_lv_pmos w=4u l=1u ng=2 m=2 mm_ok=1
XM30 net4 net3 GND GND sg13_lv_nmos w=4u l=1u ng=2 m=2 mm_ok=1
Vcurmain net5 net4 0
.save i(vcurmain)
XM2 net3 net3 GND GND sg13_lv_nmos w=4u l=1u ng=2 m=2 mm_ok=1
XM3 net5 net1 VDD VDD sg13_lv_pmos w=4u l=1u ng=2 m=2 mm_ok=1
XM4 net6 net6 GND GND sg13_lv_nmos w=4u l=1u ng=2 m=2 mm_ok=1
XM5 net7 net6 net8 GND sg13_lv_nmos w=4u l=1u ng=2 m=8 mm_ok=1
XR4 net8 GND sub! rppd w=1e-6 l=8.4e-6 m=1 b=2 mm_ok=1
**** begin user architecture code

  .lib $::MODELS_NGSPICE/cornerCAP.lib cap_typ
  .lib cornerMOSlv.lib mos_tt
  .lib cornerRES.lib res_typ



* Note! Since this script is wrapped in tcleval,
* code that is written in square brackets are in TCL scripting language
*
* The rest of the code is in spice scripting language

* Disabled because of computational cost/memory usage for big designs
* Save FET params like ids, gm, gds, vth, vgs, vdss, vds, cgg, cgsol, cgdol
* for annotation later (easier debugging and analysis)
.include [file rootname [file tail [xschem get current_name]]].save

* Customized code to include spice model for simulation
.include sg13g2_stdcell.spice

.options temp=25

.control
  save all

  op

  write [file rootname [file tail [xschem get current_name]]].raw

  set appendwrite
  dc Vdd 0.0 1.2 0.01

  write [file rootname [file tail [xschem get current_name]]].raw


  * I DID NOT USE THE BELOW, because if an error occured we wouldn't know
  * Automatically close the popup after simulation complete *
  * quit
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
