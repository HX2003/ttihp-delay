v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
B 2 0 -1120 800 -720 {flags=graph
y1=-0.88138574
y2=1.8344686
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=3.3507005e-10
x2=1.6214993e-09
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
divx=5
hilight_wave=0
color="6 7 8"
node="in
sig2
sig3"}
B 2 0 -690 800 -290 {flags=graph
y1=-0.74589639
y2=1.6569178
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=3.3507005e-10
x2=1.6214993e-09
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
divx=5
hilight_wave=0
color="11 8 21 20 4"
node="out_nomux
out_transgatemux4_1
out_transgateredrivemux4_1
out_transgatemuxtree2_1
out_standardcellmux4_1"
hcursor2_y=0.48998217
legend=1}
T {Ctrl-Click to execute launcher} 20 -260 0 0 0.3 0.3 {layer=11}
T {Inactive tranmission gate} -670 30 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -670 330 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -670 630 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -710 5700 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -710 6270 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -350 6000 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -710 5970 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -710 7000 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -710 7570 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -350 7300 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -710 7270 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -710 6710 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -710 8260 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -710 8830 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -350 8560 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -710 8530 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -710 7970 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -720 9530 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -720 10100 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -360 9830 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -720 9800 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -720 9240 0 0 0.2 0.2 {}
T {Inactive tranmission gate} 860 7670 0 0 0.2 0.2 {}
T {Inactive tranmission gate} 860 8240 0 0 0.2 0.2 {}
T {Inactive tranmission gate} 1220 7970 0 0 0.2 0.2 {}
T {Inactive tranmission gate} 860 7940 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -670 1300 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -670 1600 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -670 1900 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -670 990 0 0 0.2 0.2 {}
T {Inactive tranmission gate} 40 2010 0 0 0.2 0.2 {}
T {Inactive tranmission gate} 40 2310 0 0 0.2 0.2 {}
T {Inactive tranmission gate} 40 2610 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -670 2670 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -670 2970 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -670 3270 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -670 2360 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -660 4090 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -660 4390 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -660 4690 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -660 3780 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -730 10990 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -730 11290 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -730 11590 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -730 12260 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -730 12560 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -730 12860 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -730 11950 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -20 12970 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -20 13270 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -20 13570 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -730 13630 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -730 13930 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -730 14230 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -730 13320 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -720 15050 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -720 15350 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -720 15650 0 0 0.2 0.2 {}
T {Inactive tranmission gate} -720 14740 0 0 0.2 0.2 {}
N -680 -290 -680 -210 {lab=sig3}
N -710 -350 -710 -290 {lab=VDD}
N -710 -260 -710 -210 {lab=GND}
N -680 20 -680 90 {lab=sig3}
N -710 -50 -710 10 {lab=VDD}
N -710 40 -710 90 {lab=GND}
N -740 -50 -740 90 {lab=VDD}
N -740 -290 -740 -210 {lab=sig2}
N -680 330 -680 390 {lab=sig3}
N -710 250 -710 310 {lab=VDD}
N -710 340 -710 390 {lab=GND}
N -740 250 -740 390 {lab=VDD}
N -680 630 -680 690 {lab=sig3}
N -710 550 -710 610 {lab=VDD}
N -710 640 -710 690 {lab=GND}
N -740 550 -740 690 {lab=VDD}
N -680 -290 -530 -290 {lab=sig3}
N -680 -350 -680 -290 {lab=sig3}
N -530 330 -530 630 {lab=sig3}
N -680 20 -530 20 {lab=sig3}
N -680 -50 -680 20 {lab=sig3}
N -530 -290 -530 20 {lab=sig3}
N -680 330 -530 330 {lab=sig3}
N -680 250 -680 330 {lab=sig3}
N -530 150 -530 330 {lab=sig3}
N -680 630 -530 630 {lab=sig3}
N -680 550 -680 630 {lab=sig3}
N -850 -290 -740 -290 {lab=sig2}
N -740 -350 -740 -290 {lab=sig2}
N -1390 -50 -1350 -50 {lab=VSS}
N -1290 -50 -1250 -50 {lab=GND}
N -1030 -470 -1010 -470 {lab=in}
N -850 -470 -500 -470 {lab=#net1}
N -340 -470 -300 -470 {lab=out_nomux}
N -730 -1660 -730 -1580 {lab=VDD}
N -730 -1540 -730 -1510 {lab=GND}
N -790 -1700 -730 -1700 {lab=#net2}
N -1030 -1700 -950 -1700 {lab=in}
N 0 -1190 40 -1190 {lab=out_standardcellmux4_1}
N -320 -1190 -160 -1190 {lab=#net3}
N -720 5400 -720 5480 {lab=#net4}
N -750 5340 -750 5400 {lab=VDD}
N -750 5430 -750 5480 {lab=GND}
N -780 5400 -780 5480 {lab=#net5}
N -720 5400 -570 5400 {lab=#net4}
N -720 5340 -720 5400 {lab=#net4}
N -890 5400 -780 5400 {lab=#net5}
N -780 5340 -780 5400 {lab=#net5}
N -1030 -300 -1010 -290 {lab=in}
N -720 5700 -720 5760 {lab=#net4}
N -750 5620 -750 5680 {lab=VDD}
N -750 5710 -750 5760 {lab=GND}
N -720 5700 -570 5700 {lab=#net4}
N -720 5620 -720 5700 {lab=#net4}
N -1070 5400 -1030 -300 {lab=in}
N -720 5970 -720 6050 {lab=VDD}
N -750 5910 -750 5970 {lab=VDD}
N -750 6000 -750 6050 {lab=GND}
N -720 5970 -570 5970 {lab=VDD}
N -720 5910 -720 5970 {lab=VDD}
N -780 5910 -780 6050 {lab=VDD}
N -720 6270 -720 6330 {lab=VDD}
N -750 6190 -750 6250 {lab=VDD}
N -750 6280 -750 6330 {lab=GND}
N -780 6190 -780 6330 {lab=VDD}
N -570 5970 -570 6270 {lab=VDD}
N -720 6270 -570 6270 {lab=VDD}
N -720 6190 -720 6270 {lab=VDD}
N -780 5620 -780 5770 {lab=VDD}
N -360 5700 -360 5780 {lab=#net6}
N -390 5640 -390 5700 {lab=VDD}
N -390 5730 -390 5780 {lab=GND}
N -420 5700 -420 5780 {lab=#net4}
N -360 5700 -210 5700 {lab=#net6}
N -360 5640 -360 5700 {lab=#net6}
N -420 5640 -420 5700 {lab=#net4}
N -360 6000 -360 6060 {lab=#net6}
N -390 5920 -390 5980 {lab=VDD}
N -390 6010 -390 6060 {lab=GND}
N -210 5850 -210 6000 {lab=#net6}
N -360 6000 -210 6000 {lab=#net6}
N -360 5920 -360 6000 {lab=#net6}
N -420 5970 -420 6070 {lab=VDD}
N -570 5700 -420 5700 {lab=#net4}
N -570 5400 -570 5700 {lab=#net4}
N -570 5970 -420 5970 {lab=VDD}
N -420 5920 -420 5970 {lab=VDD}
N 1730 7820 1810 7820 {lab=out_transgatemuxtree2_1}
N -740 -1260 -740 -1230 {lab=GND}
N -740 -1420 -740 -1300 {lab=VDD}
N -740 -980 -740 -950 {lab=GND}
N -740 -1140 -740 -1020 {lab=VDD}
N -750 -710 -750 -680 {lab=GND}
N -750 -870 -750 -750 {lab=VDD}
N -400 -1090 -400 -1060 {lab=GND}
N -650 -1640 -400 -1250 {lab=#net7}
N -660 -1360 -400 -1210 {lab=#net8}
N -660 -1080 -400 -1170 {lab=#net9}
N -670 -810 -400 -1130 {lab=#net10}
N -210 5850 0 5850 {lab=#net6}
N -210 5700 -210 5850 {lab=#net6}
N -1230 -1700 -1030 -1700 {lab=in}
N -1030 -1700 -1030 -470 {lab=in}
N -1230 -1700 -1230 -1690 {lab=in}
N -720 6700 -720 6780 {lab=#net11}
N -750 6640 -750 6700 {lab=VDD}
N -750 6730 -750 6780 {lab=GND}
N -720 6700 -570 6700 {lab=#net11}
N -720 6640 -720 6700 {lab=#net11}
N -780 6640 -780 6780 {lab=VDD}
N -720 7000 -720 7060 {lab=#net11}
N -750 6920 -750 6980 {lab=VDD}
N -750 7010 -750 7060 {lab=GND}
N -720 7000 -570 7000 {lab=#net11}
N -720 6920 -720 7000 {lab=#net11}
N -720 7270 -720 7350 {lab=VDD}
N -750 7210 -750 7270 {lab=VDD}
N -750 7300 -750 7350 {lab=GND}
N -720 7270 -570 7270 {lab=VDD}
N -720 7210 -720 7270 {lab=VDD}
N -780 7210 -780 7350 {lab=VDD}
N -720 7570 -720 7630 {lab=VDD}
N -750 7490 -750 7550 {lab=VDD}
N -750 7580 -750 7630 {lab=GND}
N -780 7490 -780 7630 {lab=VDD}
N -570 7270 -570 7570 {lab=VDD}
N -720 7570 -570 7570 {lab=VDD}
N -720 7490 -720 7570 {lab=VDD}
N -780 6920 -780 7070 {lab=VDD}
N -360 7000 -360 7080 {lab=#net12}
N -390 6940 -390 7000 {lab=VDD}
N -390 7030 -390 7080 {lab=GND}
N -420 7000 -420 7080 {lab=#net11}
N -360 7000 -210 7000 {lab=#net12}
N -360 6940 -360 7000 {lab=#net12}
N -420 6940 -420 7000 {lab=#net11}
N -360 7300 -360 7360 {lab=#net12}
N -390 7220 -390 7280 {lab=VDD}
N -390 7310 -390 7360 {lab=GND}
N -210 7150 -210 7300 {lab=#net12}
N -360 7300 -210 7300 {lab=#net12}
N -360 7220 -360 7300 {lab=#net12}
N -420 7270 -420 7370 {lab=VDD}
N -570 7000 -420 7000 {lab=#net11}
N -570 6700 -570 7000 {lab=#net11}
N -570 7270 -420 7270 {lab=VDD}
N -420 7220 -420 7270 {lab=VDD}
N -210 7150 0 7150 {lab=#net12}
N -210 7000 -210 7150 {lab=#net12}
N -720 7960 -720 8040 {lab=#net13}
N -750 7900 -750 7960 {lab=VDD}
N -750 7990 -750 8040 {lab=GND}
N -720 7960 -570 7960 {lab=#net13}
N -720 7900 -720 7960 {lab=#net13}
N -780 7900 -780 8040 {lab=VDD}
N -720 8260 -720 8320 {lab=#net13}
N -750 8180 -750 8240 {lab=VDD}
N -750 8270 -750 8320 {lab=GND}
N -720 8260 -570 8260 {lab=#net13}
N -720 8180 -720 8260 {lab=#net13}
N -720 8530 -720 8610 {lab=VDD}
N -750 8470 -750 8530 {lab=VDD}
N -750 8560 -750 8610 {lab=GND}
N -720 8530 -570 8530 {lab=VDD}
N -720 8470 -720 8530 {lab=VDD}
N -780 8470 -780 8610 {lab=VDD}
N -720 8830 -720 8890 {lab=VDD}
N -750 8750 -750 8810 {lab=VDD}
N -750 8840 -750 8890 {lab=GND}
N -780 8750 -780 8890 {lab=VDD}
N -570 8530 -570 8830 {lab=VDD}
N -720 8830 -570 8830 {lab=VDD}
N -720 8750 -720 8830 {lab=VDD}
N -780 8180 -780 8330 {lab=VDD}
N -360 8260 -360 8340 {lab=#net14}
N -390 8200 -390 8260 {lab=VDD}
N -390 8290 -390 8340 {lab=GND}
N -420 8260 -420 8340 {lab=#net13}
N -360 8260 -210 8260 {lab=#net14}
N -360 8200 -360 8260 {lab=#net14}
N -420 8200 -420 8260 {lab=#net13}
N -360 8560 -360 8620 {lab=#net14}
N -390 8480 -390 8540 {lab=VDD}
N -390 8570 -390 8620 {lab=GND}
N -210 8410 -210 8560 {lab=#net14}
N -360 8560 -210 8560 {lab=#net14}
N -360 8480 -360 8560 {lab=#net14}
N -420 8530 -420 8630 {lab=VDD}
N -570 8260 -420 8260 {lab=#net13}
N -570 7960 -570 8260 {lab=#net13}
N -570 8530 -420 8530 {lab=VDD}
N -420 8480 -420 8530 {lab=VDD}
N -210 8410 0 8410 {lab=#net14}
N -210 8260 -210 8410 {lab=#net14}
N -730 9230 -730 9310 {lab=#net15}
N -760 9170 -760 9230 {lab=VDD}
N -760 9260 -760 9310 {lab=GND}
N -730 9230 -580 9230 {lab=#net15}
N -730 9170 -730 9230 {lab=#net15}
N -790 9170 -790 9310 {lab=VDD}
N -730 9530 -730 9590 {lab=#net15}
N -760 9450 -760 9510 {lab=VDD}
N -760 9540 -760 9590 {lab=GND}
N -730 9530 -580 9530 {lab=#net15}
N -730 9450 -730 9530 {lab=#net15}
N -730 9800 -730 9880 {lab=VDD}
N -760 9740 -760 9800 {lab=VDD}
N -760 9830 -760 9880 {lab=GND}
N -730 9800 -580 9800 {lab=VDD}
N -730 9740 -730 9800 {lab=VDD}
N -790 9740 -790 9880 {lab=VDD}
N -730 10100 -730 10160 {lab=VDD}
N -760 10020 -760 10080 {lab=VDD}
N -760 10110 -760 10160 {lab=GND}
N -790 10020 -790 10160 {lab=VDD}
N -580 9800 -580 10100 {lab=VDD}
N -730 10100 -580 10100 {lab=VDD}
N -730 10020 -730 10100 {lab=VDD}
N -790 9450 -790 9600 {lab=VDD}
N -370 9530 -370 9610 {lab=#net16}
N -400 9470 -400 9530 {lab=VDD}
N -400 9560 -400 9610 {lab=GND}
N -430 9530 -430 9610 {lab=#net15}
N -370 9530 -220 9530 {lab=#net16}
N -370 9470 -370 9530 {lab=#net16}
N -430 9470 -430 9530 {lab=#net15}
N -370 9830 -370 9890 {lab=#net16}
N -400 9750 -400 9810 {lab=VDD}
N -400 9840 -400 9890 {lab=GND}
N -220 9680 -220 9830 {lab=#net16}
N -370 9830 -220 9830 {lab=#net16}
N -370 9750 -370 9830 {lab=#net16}
N -430 9800 -430 9900 {lab=VDD}
N -580 9530 -430 9530 {lab=#net15}
N -580 9230 -580 9530 {lab=#net15}
N -580 9800 -430 9800 {lab=VDD}
N -430 9750 -430 9800 {lab=VDD}
N -220 9680 -10 9680 {lab=#net16}
N -220 9530 -220 9680 {lab=#net16}
N 850 7370 850 7450 {lab=#net17}
N 820 7310 820 7370 {lab=VDD}
N 820 7400 820 7450 {lab=GND}
N 790 7370 790 7450 {lab=#net6}
N 850 7370 1000 7370 {lab=#net17}
N 850 7310 850 7370 {lab=#net17}
N 680 7370 790 7370 {lab=#net6}
N 790 7310 790 7370 {lab=#net6}
N 850 7670 850 7730 {lab=#net17}
N 820 7590 820 7650 {lab=VDD}
N 820 7680 820 7730 {lab=GND}
N 850 7670 1000 7670 {lab=#net17}
N 850 7590 850 7670 {lab=#net17}
N 850 7940 850 8020 {lab=VDD}
N 820 7880 820 7940 {lab=VDD}
N 820 7970 820 8020 {lab=GND}
N 850 7940 1000 7940 {lab=VDD}
N 850 7880 850 7940 {lab=VDD}
N 790 7940 790 8020 {lab=#net14}
N 850 8240 850 8300 {lab=VDD}
N 820 8160 820 8220 {lab=VDD}
N 820 8250 820 8300 {lab=GND}
N 790 8230 790 8300 {lab=#net16}
N 1000 7940 1000 8240 {lab=VDD}
N 850 8240 1000 8240 {lab=VDD}
N 850 8160 850 8240 {lab=VDD}
N 790 7670 790 7740 {lab=#net12}
N 1210 7670 1210 7750 {lab=#net18}
N 1180 7610 1180 7670 {lab=VDD}
N 1180 7700 1180 7750 {lab=GND}
N 1150 7670 1150 7750 {lab=#net17}
N 1210 7670 1360 7670 {lab=#net18}
N 1210 7610 1210 7670 {lab=#net18}
N 1150 7610 1150 7670 {lab=#net17}
N 1210 7970 1210 8030 {lab=#net18}
N 1180 7890 1180 7950 {lab=VDD}
N 1180 7980 1180 8030 {lab=GND}
N 1360 7820 1360 7970 {lab=#net18}
N 1210 7970 1360 7970 {lab=#net18}
N 1210 7890 1210 7970 {lab=#net18}
N 1150 7940 1150 8040 {lab=VDD}
N 1000 7670 1150 7670 {lab=#net17}
N 1000 7370 1000 7670 {lab=#net17}
N 1000 7940 1150 7940 {lab=VDD}
N 1150 7890 1150 7940 {lab=VDD}
N 1360 7820 1570 7820 {lab=#net18}
N 1360 7670 1360 7820 {lab=#net18}
N 0 5850 680 7370 {lab=#net6}
N 0 7150 680 7670 {lab=#net12}
N 680 7670 790 7670 {lab=#net12}
N 790 7590 790 7670 {lab=#net12}
N 0 8410 700 7940 {lab=#net14}
N 700 7940 790 7940 {lab=#net14}
N 790 7880 790 7940 {lab=#net14}
N -10 9680 720 8230 {lab=#net16}
N 720 8230 790 8230 {lab=#net16}
N 790 8160 790 8230 {lab=#net16}
N -1030 -470 -1030 -300 {lab=in}
N -1070 5400 -1050 5400 {lab=in}
N -680 980 -680 1060 {lab=#net19}
N -710 920 -710 980 {lab=VDD}
N -710 1010 -710 1060 {lab=GND}
N -680 1290 -680 1360 {lab=#net19}
N -710 1220 -710 1280 {lab=VDD}
N -710 1310 -710 1360 {lab=GND}
N -740 1220 -740 1360 {lab=VDD}
N -680 1600 -680 1660 {lab=#net19}
N -710 1520 -710 1580 {lab=VDD}
N -710 1610 -710 1660 {lab=GND}
N -740 1520 -740 1660 {lab=VDD}
N -680 1900 -680 1960 {lab=#net19}
N -710 1820 -710 1880 {lab=VDD}
N -710 1910 -710 1960 {lab=GND}
N -740 1820 -740 1960 {lab=VDD}
N -680 980 -530 980 {lab=#net19}
N -680 920 -680 980 {lab=#net19}
N -530 1600 -530 1900 {lab=#net19}
N -680 1290 -530 1290 {lab=#net19}
N -680 1220 -680 1290 {lab=#net19}
N -530 980 -530 1290 {lab=#net19}
N -680 1600 -530 1600 {lab=#net19}
N -680 1520 -680 1600 {lab=#net19}
N -530 1420 -530 1600 {lab=#net19}
N -680 1900 -530 1900 {lab=#net19}
N -680 1820 -680 1900 {lab=#net19}
N -740 920 -740 1060 {lab=VDD}
N 30 1690 30 1770 {lab=#net20}
N 0 1630 0 1690 {lab=VDD}
N 0 1720 0 1770 {lab=GND}
N 30 2000 30 2070 {lab=#net20}
N 0 1930 0 1990 {lab=VDD}
N 0 2020 0 2070 {lab=GND}
N -30 2000 -30 2070 {lab=#net19}
N 30 2310 30 2370 {lab=#net20}
N 0 2230 0 2290 {lab=VDD}
N 0 2320 0 2370 {lab=GND}
N -30 2310 -30 2370 {lab=#net21}
N 30 2610 30 2670 {lab=#net20}
N 0 2530 0 2590 {lab=VDD}
N 0 2620 0 2670 {lab=GND}
N -30 2600 -30 2670 {lab=#net22}
N 30 1690 180 1690 {lab=#net20}
N 30 1630 30 1690 {lab=#net20}
N 180 2310 180 2610 {lab=#net20}
N 30 2000 180 2000 {lab=#net20}
N 30 1930 30 2000 {lab=#net20}
N 180 1690 180 2000 {lab=#net20}
N 30 2310 180 2310 {lab=#net20}
N 30 2230 30 2310 {lab=#net20}
N 180 2000 180 2310 {lab=#net20}
N 30 2610 180 2610 {lab=#net20}
N 30 2530 30 2610 {lab=#net20}
N -30 1700 -30 1770 {lab=sig3}
N 180 1690 210 1690 {lab=#net20}
N -520 4220 -30 2600 {lab=#net22}
N -30 2530 -30 2600 {lab=#net22}
N -530 2750 -30 2310 {lab=#net21}
N -30 2230 -30 2310 {lab=#net21}
N -530 1420 -30 2000 {lab=#net19}
N -530 1290 -530 1420 {lab=#net19}
N -30 1930 -30 2000 {lab=#net19}
N -530 150 -30 1700 {lab=sig3}
N -530 20 -530 150 {lab=sig3}
N -30 1630 -30 1700 {lab=sig3}
N -680 2350 -680 2430 {lab=#net21}
N -710 2290 -710 2350 {lab=VDD}
N -710 2380 -710 2430 {lab=GND}
N -680 2660 -680 2730 {lab=#net21}
N -710 2590 -710 2650 {lab=VDD}
N -710 2680 -710 2730 {lab=GND}
N -740 2590 -740 2730 {lab=VDD}
N -680 2970 -680 3030 {lab=#net21}
N -710 2890 -710 2950 {lab=VDD}
N -710 2980 -710 3030 {lab=GND}
N -740 2890 -740 3030 {lab=VDD}
N -680 3270 -680 3330 {lab=#net21}
N -710 3190 -710 3250 {lab=VDD}
N -710 3280 -710 3330 {lab=GND}
N -740 3190 -740 3330 {lab=VDD}
N -680 2350 -530 2350 {lab=#net21}
N -680 2290 -680 2350 {lab=#net21}
N -530 2970 -530 3270 {lab=#net21}
N -680 2660 -530 2660 {lab=#net21}
N -680 2590 -680 2660 {lab=#net21}
N -530 2350 -530 2660 {lab=#net21}
N -680 2970 -530 2970 {lab=#net21}
N -680 2890 -680 2970 {lab=#net21}
N -680 3270 -530 3270 {lab=#net21}
N -680 3190 -680 3270 {lab=#net21}
N -740 2290 -740 2430 {lab=VDD}
N -530 2750 -530 2970 {lab=#net21}
N -530 2660 -530 2750 {lab=#net21}
N -670 3770 -670 3850 {lab=#net22}
N -700 3710 -700 3770 {lab=VDD}
N -700 3800 -700 3850 {lab=GND}
N -670 4080 -670 4150 {lab=#net22}
N -700 4010 -700 4070 {lab=VDD}
N -700 4100 -700 4150 {lab=GND}
N -730 4010 -730 4150 {lab=VDD}
N -670 4390 -670 4450 {lab=#net22}
N -700 4310 -700 4370 {lab=VDD}
N -700 4400 -700 4450 {lab=GND}
N -730 4310 -730 4450 {lab=VDD}
N -670 4690 -670 4750 {lab=#net22}
N -700 4610 -700 4670 {lab=VDD}
N -700 4700 -700 4750 {lab=GND}
N -730 4610 -730 4750 {lab=VDD}
N -670 3770 -520 3770 {lab=#net22}
N -670 3710 -670 3770 {lab=#net22}
N -520 4390 -520 4690 {lab=#net22}
N -670 4080 -520 4080 {lab=#net22}
N -670 4010 -670 4080 {lab=#net22}
N -520 3770 -520 4080 {lab=#net22}
N -670 4390 -520 4390 {lab=#net22}
N -670 4310 -670 4390 {lab=#net22}
N -520 4220 -520 4390 {lab=#net22}
N -670 4690 -520 4690 {lab=#net22}
N -670 4610 -670 4690 {lab=#net22}
N -730 3710 -730 3850 {lab=VDD}
N -520 4080 -520 4220 {lab=#net22}
N -740 10670 -740 10750 {lab=#net23}
N -770 10610 -770 10670 {lab=VDD}
N -770 10700 -770 10750 {lab=GND}
N -740 10980 -740 11050 {lab=#net23}
N -770 10910 -770 10970 {lab=VDD}
N -770 11000 -770 11050 {lab=GND}
N -800 10910 -800 11050 {lab=VDD}
N -800 10670 -800 10750 {lab=#net24}
N -740 11290 -740 11350 {lab=#net23}
N -770 11210 -770 11270 {lab=VDD}
N -770 11300 -770 11350 {lab=GND}
N -800 11210 -800 11350 {lab=VDD}
N -740 11590 -740 11650 {lab=#net23}
N -770 11510 -770 11570 {lab=VDD}
N -770 11600 -770 11650 {lab=GND}
N -800 11510 -800 11650 {lab=VDD}
N -740 10670 -590 10670 {lab=#net23}
N -740 10610 -740 10670 {lab=#net23}
N -590 11290 -590 11590 {lab=#net23}
N -740 10980 -590 10980 {lab=#net23}
N -740 10910 -740 10980 {lab=#net23}
N -590 10670 -590 10980 {lab=#net23}
N -740 11290 -590 11290 {lab=#net23}
N -740 11210 -740 11290 {lab=#net23}
N -590 11130 -590 11290 {lab=#net23}
N -740 11590 -590 11590 {lab=#net23}
N -740 11510 -740 11590 {lab=#net23}
N -910 10670 -800 10670 {lab=#net24}
N -800 10610 -800 10670 {lab=#net24}
N -740 11940 -740 12020 {lab=#net25}
N -770 11880 -770 11940 {lab=VDD}
N -770 11970 -770 12020 {lab=GND}
N -740 12250 -740 12320 {lab=#net25}
N -770 12180 -770 12240 {lab=VDD}
N -770 12270 -770 12320 {lab=GND}
N -800 12180 -800 12320 {lab=VDD}
N -740 12560 -740 12620 {lab=#net25}
N -770 12480 -770 12540 {lab=VDD}
N -770 12570 -770 12620 {lab=GND}
N -800 12480 -800 12620 {lab=VDD}
N -740 12860 -740 12920 {lab=#net25}
N -770 12780 -770 12840 {lab=VDD}
N -770 12870 -770 12920 {lab=GND}
N -800 12780 -800 12920 {lab=VDD}
N -740 11940 -590 11940 {lab=#net25}
N -740 11880 -740 11940 {lab=#net25}
N -590 12560 -590 12860 {lab=#net25}
N -740 12250 -590 12250 {lab=#net25}
N -740 12180 -740 12250 {lab=#net25}
N -590 11940 -590 12250 {lab=#net25}
N -740 12560 -590 12560 {lab=#net25}
N -740 12480 -740 12560 {lab=#net25}
N -740 12860 -590 12860 {lab=#net25}
N -740 12780 -740 12860 {lab=#net25}
N -800 11880 -800 12020 {lab=VDD}
N -30 12650 -30 12730 {lab=#net26}
N -60 12590 -60 12650 {lab=VDD}
N -60 12680 -60 12730 {lab=GND}
N -30 12960 -30 13030 {lab=#net26}
N -60 12890 -60 12950 {lab=VDD}
N -60 12980 -60 13030 {lab=GND}
N -30 13270 -30 13330 {lab=#net26}
N -60 13190 -60 13250 {lab=VDD}
N -60 13280 -60 13330 {lab=GND}
N -30 13570 -30 13630 {lab=#net26}
N -60 13490 -60 13550 {lab=VDD}
N -60 13580 -60 13630 {lab=GND}
N -30 12650 120 12650 {lab=#net26}
N -30 12590 -30 12650 {lab=#net26}
N 120 13270 120 13570 {lab=#net26}
N -30 12960 120 12960 {lab=#net26}
N -30 12890 -30 12960 {lab=#net26}
N 120 12650 120 12960 {lab=#net26}
N -30 13270 120 13270 {lab=#net26}
N -30 13190 -30 13270 {lab=#net26}
N 120 12960 120 13270 {lab=#net26}
N -30 13570 120 13570 {lab=#net26}
N -30 13490 -30 13570 {lab=#net26}
N -90 13570 -90 13630 {lab=#net27}
N -90 13250 -90 13330 {lab=#net28}
N -590 12400 -590 12560 {lab=#net25}
N -90 12960 -90 13030 {lab=#net29}
N -590 10980 -590 11130 {lab=#net23}
N -90 12670 -90 12730 {lab=#net30}
N -740 13310 -740 13390 {lab=#net31}
N -770 13250 -770 13310 {lab=VDD}
N -770 13340 -770 13390 {lab=GND}
N -740 13620 -740 13690 {lab=#net31}
N -770 13550 -770 13610 {lab=VDD}
N -770 13640 -770 13690 {lab=GND}
N -800 13550 -800 13690 {lab=VDD}
N -740 13930 -740 13990 {lab=#net31}
N -770 13850 -770 13910 {lab=VDD}
N -770 13940 -770 13990 {lab=GND}
N -800 13850 -800 13990 {lab=VDD}
N -740 14230 -740 14290 {lab=#net31}
N -770 14150 -770 14210 {lab=VDD}
N -770 14240 -770 14290 {lab=GND}
N -800 14150 -800 14290 {lab=VDD}
N -740 13310 -590 13310 {lab=#net31}
N -740 13250 -740 13310 {lab=#net31}
N -590 13930 -590 14230 {lab=#net31}
N -740 13620 -590 13620 {lab=#net31}
N -740 13550 -740 13620 {lab=#net31}
N -590 13310 -590 13620 {lab=#net31}
N -740 13930 -590 13930 {lab=#net31}
N -740 13850 -740 13930 {lab=#net31}
N -740 14230 -590 14230 {lab=#net31}
N -740 14150 -740 14230 {lab=#net31}
N -800 13250 -800 13390 {lab=VDD}
N -590 13780 -590 13930 {lab=#net31}
N -730 14730 -730 14810 {lab=#net32}
N -760 14670 -760 14730 {lab=VDD}
N -760 14760 -760 14810 {lab=GND}
N -730 15040 -730 15110 {lab=#net32}
N -760 14970 -760 15030 {lab=VDD}
N -760 15060 -760 15110 {lab=GND}
N -790 14970 -790 15110 {lab=VDD}
N -730 15350 -730 15410 {lab=#net32}
N -760 15270 -760 15330 {lab=VDD}
N -760 15360 -760 15410 {lab=GND}
N -790 15270 -790 15410 {lab=VDD}
N -730 15650 -730 15710 {lab=#net32}
N -760 15570 -760 15630 {lab=VDD}
N -760 15660 -760 15710 {lab=GND}
N -790 15570 -790 15710 {lab=VDD}
N -730 14730 -580 14730 {lab=#net32}
N -730 14670 -730 14730 {lab=#net32}
N -580 15350 -580 15650 {lab=#net32}
N -730 15040 -580 15040 {lab=#net32}
N -730 14970 -730 15040 {lab=#net32}
N -580 14730 -580 15040 {lab=#net32}
N -730 15350 -580 15350 {lab=#net32}
N -730 15270 -730 15350 {lab=#net32}
N -730 15650 -580 15650 {lab=#net32}
N -730 15570 -730 15650 {lab=#net32}
N -790 14670 -790 14810 {lab=VDD}
N -580 15210 -580 15350 {lab=#net32}
N -1070 5400 -1070 10670 {lab=in}
N -1070 5390 -1070 5400 {lab=in}
N -590 11130 -560 11130 {lab=#net23}
N -480 11130 -90 12670 {lab=#net30}
N -90 12590 -90 12670 {lab=#net30}
N -590 12400 -560 12400 {lab=#net25}
N -590 12250 -590 12400 {lab=#net25}
N -480 12400 -90 12960 {lab=#net29}
N -90 12890 -90 12960 {lab=#net29}
N -590 13780 -560 13780 {lab=#net31}
N -590 13620 -590 13780 {lab=#net31}
N -480 13780 -90 13250 {lab=#net28}
N -90 13190 -90 13250 {lab=#net28}
N -580 15210 -550 15210 {lab=#net32}
N -580 15040 -580 15210 {lab=#net32}
N -470 15210 -90 13570 {lab=#net27}
N -90 13490 -90 13570 {lab=#net27}
N 120 12650 130 12650 {lab=#net26}
C {code_shown.sym} 20 -100 0 0 {name=MODEL only_toplevel=false format="tcleval( @value )"

value="
  .lib $::MODELS_NGSPICE/cornerCAP.lib cap_typ
  .lib cornerMOSlv.lib mos_tt
  .lib cornerRES.lib res_typ
"



}
C {devices/launcher.sym} 70 -160 0 0 {name=h1
descr="Ctrl + Left Click to Annotate and load waves" 
tclcommand="
xschem annotate_op
xschem raw_read $netlist_dir/[file rootname [file tail [xschem get current_name]]].raw tran
xschem setprop rect 2 0 fullxzoom
"
}
C {launcher.sym} 72.33626929682691 -220 0 0 {name=h3
descr="Ctrl + Left Click to Simulate NGSPICE"
tclcommand="
# Setup the default simulation commands if not already set up
# for example by already launched simulations.
set_sim_defaults
puts $sim(spice,1,cmd) 

# Change the Xyce command. In the spice category there are currently
# 5 commands (0, 1, 2, 3, 4). Command 3 is the Xyce batch
# you can get the number by querying $sim(spice,n)
set sim(spice,1,cmd) \{ngspice  \\"$N\\" -a\}

# change the simulator to be used (Xyce)
set sim(spice,default) 0

# Create FET and BIP .save file
mkdir -p $netlist_dir
write_data [save_params] $netlist_dir/[file rootname [file tail [xschem get current_name]]].save

# Generate netlist
xschem netlist

# Run simulation
simulate

# While its nice to be able to wait for the simulation to complete,
# then automatically annotate and load waves,
# The following waits for the simulation popup to close,
# so if its not closed, then it will keep waiting

# set id1 [simulate]
# vwait execute(exitcode,$id1)
# put "done!"

"
}
C {code_shown.sym} 20 20 0 0 {name=NGSPICE only_toplevel=true 
value="tcleval(
* Note! Since this script is wrapped in tcleval,
* code that is written in square brackets are in TCL scripting language
*
* The rest of the code is in spice scripting language

* Disabled because of computational cost/memory usage for big designs
* Save FET params like ids, gm, gds, vth, vgs, vdss, vds, cgg, cgsol, cgdol
* for annotation later (easier debugging and analysis)
* .include [file rootname [file tail [xschem get current_name]]].save

* Customized code to include spice model for simulation

*.include sg13g2_stdcell.spice
.options temp=25


.control
  save all

  tran 1p 2n

  write [file rootname [file tail [xschem get current_name]]].raw

  * I DID NOT USE THE BELOW, because if an error occured we wouldn't know
  * Automatically close the popup after simulation complete *
  * quit
.endc
)"}
C {sg13g2_pr/sg13_lv_nmos.sym} -710 -190 3 0 {name=M12
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -710 -370 1 0 {name=M15
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {devices/vsource.sym} -1250 -80 0 0 {name=V2 value="PWL(0ns 0 0.1ns 1.2)"}
C {gnd.sym} -1250 -50 0 0 {name=l2 lab=GND}
C {lab_pin.sym} -1250 -110 2 0 {name=p13 lab=VDD}
C {lab_pin.sym} -830 -290 2 0 {name=p1 lab=sig2}
C {lab_pin.sym} -640 -290 2 0 {name=p2 lab=sig3}
C {devices/vsource.sym} -1230 -1660 0 0 {name=V1 value="PWL(0ns 0 1ns 0 1.1ns 1.2)"}
C {lab_pin.sym} -710 -170 2 0 {name=p3 lab=VDD}
C {gnd.sym} -710 -390 2 0 {name=l1 lab=GND}
C {gnd.sym} -710 -260 2 0 {name=l3 lab=GND}
C {lab_pin.sym} -710 -290 2 0 {name=p4 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -710 110 3 0 {name=M1
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -710 -70 1 0 {name=M2
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -710 -90 2 0 {name=p5 lab=VDD}
C {gnd.sym} -710 40 2 0 {name=l4 lab=GND}
C {lab_pin.sym} -710 10 2 0 {name=p6 lab=VDD}
C {gnd.sym} -710 130 0 0 {name=l5 lab=GND}
C {gnd.sym} -1230 -1630 0 0 {name=l6 lab=GND}
C {lab_pin.sym} -740 20 0 0 {name=p7 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -710 410 3 0 {name=M3
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -710 230 1 0 {name=M4
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -710 210 2 0 {name=p8 lab=VDD}
C {gnd.sym} -710 340 2 0 {name=l7 lab=GND}
C {lab_pin.sym} -710 310 2 0 {name=p9 lab=VDD}
C {gnd.sym} -710 430 0 0 {name=l8 lab=GND}
C {lab_pin.sym} -740 320 0 0 {name=p10 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -710 710 3 0 {name=M5
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -710 530 1 0 {name=M6
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -710 510 2 0 {name=p11 lab=VDD}
C {gnd.sym} -710 640 2 0 {name=l9 lab=GND}
C {lab_pin.sym} -710 610 2 0 {name=p12 lab=VDD}
C {gnd.sym} -710 730 0 0 {name=l10 lab=GND}
C {lab_pin.sym} -740 620 0 0 {name=p14 lab=VDD}
C {sg13g2_stdcells/sg13g2_inv_1.sym} -970 -290 0 0 {name=x32 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} -890 -290 0 0 {name=x1 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} -1390 -50 0 0 {name=p15 lab=VSS}
C {res.sym} -1320 -50 1 0 {name=R1
value=0.00001
footprint=1206
device=resistor
m=1}
C {sg13g2_stdcells/sg13g2_inv_1.sym} -970 -470 0 0 {name=x4 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} -890 -470 0 0 {name=x5 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} -1030 -380 0 0 {name=p16 lab=in}
C {sg13g2_stdcells/sg13g2_inv_1.sym} -460 -470 0 0 {name=x6 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} -380 -470 0 0 {name=x7 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} -300 -470 2 0 {name=p17 lab=out_nomux}
C {lab_pin.sym} 370 1690 2 0 {name=p18 lab=out_transgatemux4_1}
C {sg13g2_stdcells/sg13g2_mux4_1.sym} -690 -1640 0 0 {name=x24 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} -730 -1660 0 0 {name=p19 lab=VDD}
C {gnd.sym} -730 -1510 0 0 {name=l11 lab=GND}
C {sg13g2_stdcells/sg13g2_inv_1.sym} -910 -1700 0 0 {name=x8 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} -830 -1700 0 0 {name=x9 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} -120 -1190 0 0 {name=x10 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} -40 -1190 0 0 {name=x11 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} 40 -1190 2 0 {name=p20 lab=out_standardcellmux4_1}
C {sg13g2_pr/sg13_lv_nmos.sym} -750 5500 3 0 {name=M7
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -750 5320 1 0 {name=M8
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -750 5520 2 0 {name=p23 lab=VDD}
C {gnd.sym} -750 5300 2 0 {name=l12 lab=GND}
C {gnd.sym} -750 5430 2 0 {name=l13 lab=GND}
C {lab_pin.sym} -750 5400 2 0 {name=p24 lab=VDD}
C {sg13g2_stdcells/sg13g2_inv_1.sym} -1010 5400 0 0 {name=x12 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} -930 5400 0 0 {name=x13 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_pr/sg13_lv_nmos.sym} -750 5780 3 0 {name=M9
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -750 5600 1 0 {name=M10
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -750 5580 2 0 {name=p25 lab=VDD}
C {gnd.sym} -750 5710 2 0 {name=l14 lab=GND}
C {lab_pin.sym} -750 5680 2 0 {name=p26 lab=VDD}
C {gnd.sym} -750 5800 0 0 {name=l15 lab=GND}
C {lab_pin.sym} -780 5690 0 0 {name=p27 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -750 6070 3 0 {name=M11
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -750 5890 1 0 {name=M13
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -750 6090 2 0 {name=p21 lab=VDD}
C {gnd.sym} -750 6000 2 0 {name=l16 lab=GND}
C {lab_pin.sym} -750 5970 2 0 {name=p22 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -750 6350 3 0 {name=M14
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -750 6170 1 0 {name=M16
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -750 6150 2 0 {name=p28 lab=VDD}
C {gnd.sym} -750 6280 2 0 {name=l17 lab=GND}
C {lab_pin.sym} -750 6250 2 0 {name=p29 lab=VDD}
C {gnd.sym} -750 6370 0 0 {name=l18 lab=GND}
C {lab_pin.sym} -780 6260 0 0 {name=p30 lab=VDD}
C {lab_pin.sym} -780 5980 0 0 {name=p31 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -390 5800 3 0 {name=M17
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -390 5620 1 0 {name=M18
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} -390 5730 2 0 {name=l19 lab=GND}
C {lab_pin.sym} -390 5700 2 0 {name=p33 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -390 6080 3 0 {name=M19
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -390 5900 1 0 {name=M20
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -390 5880 2 0 {name=p34 lab=VDD}
C {gnd.sym} -390 6010 2 0 {name=l20 lab=GND}
C {lab_pin.sym} -390 5980 2 0 {name=p35 lab=VDD}
C {gnd.sym} -390 6100 0 0 {name=l21 lab=GND}
C {lab_pin.sym} -420 5990 0 0 {name=p36 lab=VDD}
C {lab_pin.sym} -390 5820 2 0 {name=p32 lab=VDD}
C {gnd.sym} -390 5600 2 0 {name=l22 lab=GND}
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1610 7820 0 0 {name=x14 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 1690 7820 0 0 {name=x15 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} 1810 7820 2 0 {name=p37 lab=out_transgatemuxtree2_1}
C {lab_pin.sym} -750 5870 2 0 {name=p38 lab=VDD}
C {sg13g2_stdcells/sg13g2_mux4_1.sym} -700 -1360 0 0 {name=x16 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} -740 -1420 0 0 {name=p39 lab=VDD}
C {gnd.sym} -740 -1230 0 0 {name=l23 lab=GND}
C {sg13g2_stdcells/sg13g2_mux4_1.sym} -700 -1080 0 0 {name=x17 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} -740 -1140 0 0 {name=p40 lab=VDD}
C {gnd.sym} -740 -950 0 0 {name=l24 lab=GND}
C {sg13g2_stdcells/sg13g2_mux4_1.sym} -710 -810 0 0 {name=x18 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} -750 -870 0 0 {name=p41 lab=VDD}
C {gnd.sym} -750 -680 0 0 {name=l25 lab=GND}
C {sg13g2_stdcells/sg13g2_mux4_1.sym} -360 -1190 0 0 {name=x19 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {gnd.sym} -400 -1060 0 0 {name=l26 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} -750 6800 3 0 {name=M21
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -750 6620 1 0 {name=M22
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -750 6820 2 0 {name=p42 lab=VDD}
C {gnd.sym} -750 6600 2 0 {name=l27 lab=GND}
C {gnd.sym} -750 6730 2 0 {name=l28 lab=GND}
C {lab_pin.sym} -750 6700 2 0 {name=p43 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -750 7080 3 0 {name=M23
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -750 6900 1 0 {name=M24
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -750 6880 2 0 {name=p44 lab=VDD}
C {gnd.sym} -750 7010 2 0 {name=l29 lab=GND}
C {lab_pin.sym} -750 6980 2 0 {name=p45 lab=VDD}
C {gnd.sym} -750 7100 0 0 {name=l30 lab=GND}
C {lab_pin.sym} -780 6990 0 0 {name=p46 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -750 7370 3 0 {name=M25
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -750 7190 1 0 {name=M26
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -750 7390 2 0 {name=p47 lab=VDD}
C {gnd.sym} -750 7300 2 0 {name=l31 lab=GND}
C {lab_pin.sym} -750 7270 2 0 {name=p48 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -750 7650 3 0 {name=M27
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -750 7470 1 0 {name=M28
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -750 7450 2 0 {name=p49 lab=VDD}
C {gnd.sym} -750 7580 2 0 {name=l32 lab=GND}
C {lab_pin.sym} -750 7550 2 0 {name=p50 lab=VDD}
C {gnd.sym} -750 7670 0 0 {name=l33 lab=GND}
C {lab_pin.sym} -780 7560 0 0 {name=p51 lab=VDD}
C {lab_pin.sym} -780 7280 0 0 {name=p52 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -390 7100 3 0 {name=M29
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -390 6920 1 0 {name=M30
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} -390 7030 2 0 {name=l34 lab=GND}
C {lab_pin.sym} -390 7000 2 0 {name=p53 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -390 7380 3 0 {name=M31
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -390 7200 1 0 {name=M32
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -390 7180 2 0 {name=p54 lab=VDD}
C {gnd.sym} -390 7310 2 0 {name=l35 lab=GND}
C {lab_pin.sym} -390 7280 2 0 {name=p55 lab=VDD}
C {gnd.sym} -390 7400 0 0 {name=l36 lab=GND}
C {lab_pin.sym} -420 7290 0 0 {name=p56 lab=VDD}
C {lab_pin.sym} -390 7120 2 0 {name=p57 lab=VDD}
C {gnd.sym} -390 6900 2 0 {name=l37 lab=GND}
C {lab_pin.sym} -750 7170 2 0 {name=p58 lab=VDD}
C {lab_pin.sym} -780 6700 0 0 {name=p59 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -750 8060 3 0 {name=M33
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -750 7880 1 0 {name=M34
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -750 8080 2 0 {name=p60 lab=VDD}
C {gnd.sym} -750 7860 2 0 {name=l38 lab=GND}
C {gnd.sym} -750 7990 2 0 {name=l39 lab=GND}
C {lab_pin.sym} -750 7960 2 0 {name=p61 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -750 8340 3 0 {name=M35
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -750 8160 1 0 {name=M36
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -750 8140 2 0 {name=p62 lab=VDD}
C {gnd.sym} -750 8270 2 0 {name=l40 lab=GND}
C {lab_pin.sym} -750 8240 2 0 {name=p63 lab=VDD}
C {gnd.sym} -750 8360 0 0 {name=l41 lab=GND}
C {lab_pin.sym} -780 8250 0 0 {name=p64 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -750 8630 3 0 {name=M37
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -750 8450 1 0 {name=M38
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -750 8650 2 0 {name=p65 lab=VDD}
C {gnd.sym} -750 8560 2 0 {name=l42 lab=GND}
C {lab_pin.sym} -750 8530 2 0 {name=p66 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -750 8910 3 0 {name=M39
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -750 8730 1 0 {name=M40
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -750 8710 2 0 {name=p67 lab=VDD}
C {gnd.sym} -750 8840 2 0 {name=l43 lab=GND}
C {lab_pin.sym} -750 8810 2 0 {name=p68 lab=VDD}
C {gnd.sym} -750 8930 0 0 {name=l44 lab=GND}
C {lab_pin.sym} -780 8820 0 0 {name=p69 lab=VDD}
C {lab_pin.sym} -780 8540 0 0 {name=p70 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -390 8360 3 0 {name=M41
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -390 8180 1 0 {name=M42
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} -390 8290 2 0 {name=l45 lab=GND}
C {lab_pin.sym} -390 8260 2 0 {name=p71 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -390 8640 3 0 {name=M43
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -390 8460 1 0 {name=M44
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -390 8440 2 0 {name=p72 lab=VDD}
C {gnd.sym} -390 8570 2 0 {name=l46 lab=GND}
C {lab_pin.sym} -390 8540 2 0 {name=p73 lab=VDD}
C {gnd.sym} -390 8660 0 0 {name=l47 lab=GND}
C {lab_pin.sym} -420 8550 0 0 {name=p74 lab=VDD}
C {lab_pin.sym} -390 8380 2 0 {name=p75 lab=VDD}
C {gnd.sym} -390 8160 2 0 {name=l48 lab=GND}
C {lab_pin.sym} -750 8430 2 0 {name=p76 lab=VDD}
C {lab_pin.sym} -780 7960 0 0 {name=p77 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -760 9330 3 0 {name=M45
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -760 9150 1 0 {name=M46
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -760 9350 2 0 {name=p78 lab=VDD}
C {gnd.sym} -760 9130 2 0 {name=l49 lab=GND}
C {gnd.sym} -760 9260 2 0 {name=l50 lab=GND}
C {lab_pin.sym} -760 9230 2 0 {name=p79 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -760 9610 3 0 {name=M47
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -760 9430 1 0 {name=M48
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -760 9410 2 0 {name=p80 lab=VDD}
C {gnd.sym} -760 9540 2 0 {name=l51 lab=GND}
C {lab_pin.sym} -760 9510 2 0 {name=p81 lab=VDD}
C {gnd.sym} -760 9630 0 0 {name=l52 lab=GND}
C {lab_pin.sym} -790 9520 0 0 {name=p82 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -760 9900 3 0 {name=M49
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -760 9720 1 0 {name=M50
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -760 9920 2 0 {name=p83 lab=VDD}
C {gnd.sym} -760 9830 2 0 {name=l53 lab=GND}
C {lab_pin.sym} -760 9800 2 0 {name=p84 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -760 10180 3 0 {name=M51
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -760 10000 1 0 {name=M52
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -760 9980 2 0 {name=p85 lab=VDD}
C {gnd.sym} -760 10110 2 0 {name=l54 lab=GND}
C {lab_pin.sym} -760 10080 2 0 {name=p86 lab=VDD}
C {gnd.sym} -760 10200 0 0 {name=l55 lab=GND}
C {lab_pin.sym} -790 10090 0 0 {name=p87 lab=VDD}
C {lab_pin.sym} -790 9810 0 0 {name=p88 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -400 9630 3 0 {name=M53
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -400 9450 1 0 {name=M54
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} -400 9560 2 0 {name=l56 lab=GND}
C {lab_pin.sym} -400 9530 2 0 {name=p89 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -400 9910 3 0 {name=M55
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -400 9730 1 0 {name=M56
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -400 9710 2 0 {name=p90 lab=VDD}
C {gnd.sym} -400 9840 2 0 {name=l57 lab=GND}
C {lab_pin.sym} -400 9810 2 0 {name=p91 lab=VDD}
C {gnd.sym} -400 9930 0 0 {name=l58 lab=GND}
C {lab_pin.sym} -430 9820 0 0 {name=p92 lab=VDD}
C {lab_pin.sym} -400 9650 2 0 {name=p93 lab=VDD}
C {gnd.sym} -400 9430 2 0 {name=l59 lab=GND}
C {lab_pin.sym} -760 9700 2 0 {name=p94 lab=VDD}
C {lab_pin.sym} -790 9230 0 0 {name=p95 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} 820 7470 3 0 {name=M57
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 820 7290 1 0 {name=M58
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 820 7490 2 0 {name=p96 lab=VDD}
C {gnd.sym} 820 7270 2 0 {name=l60 lab=GND}
C {gnd.sym} 820 7400 2 0 {name=l61 lab=GND}
C {lab_pin.sym} 820 7370 2 0 {name=p97 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} 820 7750 3 0 {name=M59
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 820 7570 1 0 {name=M60
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 820 7550 2 0 {name=p98 lab=VDD}
C {gnd.sym} 820 7680 2 0 {name=l62 lab=GND}
C {lab_pin.sym} 820 7650 2 0 {name=p99 lab=VDD}
C {gnd.sym} 820 7770 0 0 {name=l63 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 820 8040 3 0 {name=M61
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 820 7860 1 0 {name=M62
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 820 8060 2 0 {name=p101 lab=VDD}
C {gnd.sym} 820 7970 2 0 {name=l64 lab=GND}
C {lab_pin.sym} 820 7940 2 0 {name=p102 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} 820 8320 3 0 {name=M63
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 820 8140 1 0 {name=M64
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 820 8120 2 0 {name=p103 lab=VDD}
C {gnd.sym} 820 8250 2 0 {name=l65 lab=GND}
C {lab_pin.sym} 820 8220 2 0 {name=p104 lab=VDD}
C {gnd.sym} 820 8340 0 0 {name=l66 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 1180 7770 3 0 {name=M65
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1180 7590 1 0 {name=M66
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 1180 7700 2 0 {name=l67 lab=GND}
C {lab_pin.sym} 1180 7670 2 0 {name=p107 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} 1180 8050 3 0 {name=M67
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1180 7870 1 0 {name=M68
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 1180 7850 2 0 {name=p108 lab=VDD}
C {gnd.sym} 1180 7980 2 0 {name=l68 lab=GND}
C {lab_pin.sym} 1180 7950 2 0 {name=p109 lab=VDD}
C {gnd.sym} 1180 8070 0 0 {name=l69 lab=GND}
C {lab_pin.sym} 1150 7960 0 0 {name=p110 lab=VDD}
C {lab_pin.sym} 1180 7790 2 0 {name=p111 lab=VDD}
C {gnd.sym} 1180 7570 2 0 {name=l70 lab=GND}
C {lab_pin.sym} 820 7840 2 0 {name=p112 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -710 1080 3 0 {name=M69
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -710 900 1 0 {name=M70
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} -710 1010 2 0 {name=l71 lab=GND}
C {lab_pin.sym} -710 980 2 0 {name=p106 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -710 1380 3 0 {name=M71
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -710 1200 1 0 {name=M72
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -710 1180 2 0 {name=p113 lab=VDD}
C {gnd.sym} -710 1310 2 0 {name=l72 lab=GND}
C {lab_pin.sym} -710 1280 2 0 {name=p114 lab=VDD}
C {gnd.sym} -710 1400 0 0 {name=l73 lab=GND}
C {lab_pin.sym} -740 1290 0 0 {name=p115 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -710 1680 3 0 {name=M73
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -710 1500 1 0 {name=M74
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -710 1480 2 0 {name=p116 lab=VDD}
C {gnd.sym} -710 1610 2 0 {name=l74 lab=GND}
C {lab_pin.sym} -710 1580 2 0 {name=p117 lab=VDD}
C {gnd.sym} -710 1700 0 0 {name=l75 lab=GND}
C {lab_pin.sym} -740 1590 0 0 {name=p118 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -710 1980 3 0 {name=M75
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -710 1800 1 0 {name=M76
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -710 1780 2 0 {name=p119 lab=VDD}
C {gnd.sym} -710 1910 2 0 {name=l76 lab=GND}
C {lab_pin.sym} -710 1880 2 0 {name=p120 lab=VDD}
C {gnd.sym} -710 2000 0 0 {name=l77 lab=GND}
C {lab_pin.sym} -740 1890 0 0 {name=p121 lab=VDD}
C {lab_pin.sym} -740 990 0 0 {name=p122 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} 0 1790 3 0 {name=M93
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 0 1610 1 0 {name=M94
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 0 1810 2 0 {name=p147 lab=VDD}
C {gnd.sym} 0 1590 2 0 {name=l92 lab=GND}
C {gnd.sym} 0 1720 2 0 {name=l93 lab=GND}
C {lab_pin.sym} 0 1690 2 0 {name=p148 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} 0 2090 3 0 {name=M95
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 0 1910 1 0 {name=M96
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 0 1890 2 0 {name=p149 lab=VDD}
C {gnd.sym} 0 2020 2 0 {name=l94 lab=GND}
C {lab_pin.sym} 0 1990 2 0 {name=p150 lab=VDD}
C {gnd.sym} 0 2110 0 0 {name=l95 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 0 2390 3 0 {name=M97
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 0 2210 1 0 {name=M98
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 0 2190 2 0 {name=p152 lab=VDD}
C {gnd.sym} 0 2320 2 0 {name=l96 lab=GND}
C {lab_pin.sym} 0 2290 2 0 {name=p153 lab=VDD}
C {gnd.sym} 0 2410 0 0 {name=l97 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 0 2690 3 0 {name=M99
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 0 2510 1 0 {name=M100
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 0 2490 2 0 {name=p155 lab=VDD}
C {gnd.sym} 0 2620 2 0 {name=l98 lab=GND}
C {lab_pin.sym} 0 2590 2 0 {name=p156 lab=VDD}
C {gnd.sym} 0 2710 0 0 {name=l99 lab=GND}
C {sg13g2_stdcells/sg13g2_inv_1.sym} 250 1690 0 0 {name=x20 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 330 1690 0 0 {name=x21 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} -710 880 0 0 {name=p100 lab=VDD}
C {gnd.sym} -710 1100 0 0 {name=l78 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} -710 2450 3 0 {name=M77
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -710 2270 1 0 {name=M78
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} -710 2380 2 0 {name=l79 lab=GND}
C {lab_pin.sym} -710 2350 2 0 {name=p105 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -710 2750 3 0 {name=M79
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -710 2570 1 0 {name=M80
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -710 2550 2 0 {name=p123 lab=VDD}
C {gnd.sym} -710 2680 2 0 {name=l80 lab=GND}
C {lab_pin.sym} -710 2650 2 0 {name=p124 lab=VDD}
C {gnd.sym} -710 2770 0 0 {name=l81 lab=GND}
C {lab_pin.sym} -740 2660 0 0 {name=p125 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -710 3050 3 0 {name=M81
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -710 2870 1 0 {name=M82
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -710 2850 2 0 {name=p126 lab=VDD}
C {gnd.sym} -710 2980 2 0 {name=l82 lab=GND}
C {lab_pin.sym} -710 2950 2 0 {name=p127 lab=VDD}
C {gnd.sym} -710 3070 0 0 {name=l83 lab=GND}
C {lab_pin.sym} -740 2960 0 0 {name=p128 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -710 3350 3 0 {name=M83
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -710 3170 1 0 {name=M84
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -710 3150 2 0 {name=p129 lab=VDD}
C {gnd.sym} -710 3280 2 0 {name=l84 lab=GND}
C {lab_pin.sym} -710 3250 2 0 {name=p130 lab=VDD}
C {gnd.sym} -710 3370 0 0 {name=l85 lab=GND}
C {lab_pin.sym} -740 3260 0 0 {name=p131 lab=VDD}
C {lab_pin.sym} -740 2360 0 0 {name=p132 lab=VDD}
C {lab_pin.sym} -710 2250 0 0 {name=p133 lab=VDD}
C {gnd.sym} -710 2470 0 0 {name=l86 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} -700 3870 3 0 {name=M85
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -700 3690 1 0 {name=M86
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} -700 3800 2 0 {name=l87 lab=GND}
C {lab_pin.sym} -700 3770 2 0 {name=p134 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -700 4170 3 0 {name=M87
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -700 3990 1 0 {name=M88
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -700 3970 2 0 {name=p135 lab=VDD}
C {gnd.sym} -700 4100 2 0 {name=l88 lab=GND}
C {lab_pin.sym} -700 4070 2 0 {name=p136 lab=VDD}
C {gnd.sym} -700 4190 0 0 {name=l89 lab=GND}
C {lab_pin.sym} -730 4080 0 0 {name=p137 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -700 4470 3 0 {name=M89
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -700 4290 1 0 {name=M90
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -700 4270 2 0 {name=p138 lab=VDD}
C {gnd.sym} -700 4400 2 0 {name=l90 lab=GND}
C {lab_pin.sym} -700 4370 2 0 {name=p139 lab=VDD}
C {gnd.sym} -700 4490 0 0 {name=l91 lab=GND}
C {lab_pin.sym} -730 4380 0 0 {name=p140 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -700 4770 3 0 {name=M91
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -700 4590 1 0 {name=M92
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -700 4570 2 0 {name=p141 lab=VDD}
C {gnd.sym} -700 4700 2 0 {name=l100 lab=GND}
C {lab_pin.sym} -700 4670 2 0 {name=p142 lab=VDD}
C {gnd.sym} -700 4790 0 0 {name=l101 lab=GND}
C {lab_pin.sym} -730 4680 0 0 {name=p143 lab=VDD}
C {lab_pin.sym} -730 3780 0 0 {name=p144 lab=VDD}
C {lab_pin.sym} -700 3670 0 0 {name=p145 lab=VDD}
C {gnd.sym} -700 3890 0 0 {name=l102 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} -770 10770 3 0 {name=M101
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -770 10590 1 0 {name=M102
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -770 10790 2 0 {name=p154 lab=VDD}
C {gnd.sym} -770 10570 2 0 {name=l103 lab=GND}
C {gnd.sym} -770 10700 2 0 {name=l104 lab=GND}
C {lab_pin.sym} -770 10670 2 0 {name=p157 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -770 11070 3 0 {name=M103
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -770 10890 1 0 {name=M104
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -770 10870 2 0 {name=p158 lab=VDD}
C {gnd.sym} -770 11000 2 0 {name=l105 lab=GND}
C {lab_pin.sym} -770 10970 2 0 {name=p159 lab=VDD}
C {gnd.sym} -770 11090 0 0 {name=l106 lab=GND}
C {lab_pin.sym} -800 10980 0 0 {name=p160 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -770 11370 3 0 {name=M105
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -770 11190 1 0 {name=M106
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -770 11170 2 0 {name=p161 lab=VDD}
C {gnd.sym} -770 11300 2 0 {name=l107 lab=GND}
C {lab_pin.sym} -770 11270 2 0 {name=p162 lab=VDD}
C {gnd.sym} -770 11390 0 0 {name=l108 lab=GND}
C {lab_pin.sym} -800 11280 0 0 {name=p163 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -770 11670 3 0 {name=M107
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -770 11490 1 0 {name=M108
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -770 11470 2 0 {name=p164 lab=VDD}
C {gnd.sym} -770 11600 2 0 {name=l109 lab=GND}
C {lab_pin.sym} -770 11570 2 0 {name=p165 lab=VDD}
C {gnd.sym} -770 11690 0 0 {name=l110 lab=GND}
C {lab_pin.sym} -800 11580 0 0 {name=p166 lab=VDD}
C {sg13g2_stdcells/sg13g2_inv_1.sym} -1030 10670 0 0 {name=x2 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} -950 10670 0 0 {name=x3 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} 370 12650 2 0 {name=p167 lab=out_transgateredrivemux4_1}
C {sg13g2_pr/sg13_lv_nmos.sym} -770 12040 3 0 {name=M109
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -770 11860 1 0 {name=M110
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} -770 11970 2 0 {name=l111 lab=GND}
C {lab_pin.sym} -770 11940 2 0 {name=p168 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -770 12340 3 0 {name=M111
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -770 12160 1 0 {name=M112
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -770 12140 2 0 {name=p169 lab=VDD}
C {gnd.sym} -770 12270 2 0 {name=l112 lab=GND}
C {lab_pin.sym} -770 12240 2 0 {name=p170 lab=VDD}
C {gnd.sym} -770 12360 0 0 {name=l113 lab=GND}
C {lab_pin.sym} -800 12250 0 0 {name=p171 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -770 12640 3 0 {name=M113
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -770 12460 1 0 {name=M114
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -770 12440 2 0 {name=p172 lab=VDD}
C {gnd.sym} -770 12570 2 0 {name=l114 lab=GND}
C {lab_pin.sym} -770 12540 2 0 {name=p173 lab=VDD}
C {gnd.sym} -770 12660 0 0 {name=l115 lab=GND}
C {lab_pin.sym} -800 12550 0 0 {name=p174 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -770 12940 3 0 {name=M115
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -770 12760 1 0 {name=M116
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -770 12740 2 0 {name=p175 lab=VDD}
C {gnd.sym} -770 12870 2 0 {name=l116 lab=GND}
C {lab_pin.sym} -770 12840 2 0 {name=p176 lab=VDD}
C {gnd.sym} -770 12960 0 0 {name=l117 lab=GND}
C {lab_pin.sym} -800 12850 0 0 {name=p177 lab=VDD}
C {lab_pin.sym} -800 11950 0 0 {name=p178 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -60 12750 3 0 {name=M117
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -60 12570 1 0 {name=M118
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -60 12770 2 0 {name=p179 lab=VDD}
C {gnd.sym} -60 12550 2 0 {name=l118 lab=GND}
C {gnd.sym} -60 12680 2 0 {name=l119 lab=GND}
C {lab_pin.sym} -60 12650 2 0 {name=p180 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -60 13050 3 0 {name=M119
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -60 12870 1 0 {name=M120
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -60 12850 2 0 {name=p181 lab=VDD}
C {gnd.sym} -60 12980 2 0 {name=l120 lab=GND}
C {lab_pin.sym} -60 12950 2 0 {name=p182 lab=VDD}
C {gnd.sym} -60 13070 0 0 {name=l121 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} -60 13350 3 0 {name=M121
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -60 13170 1 0 {name=M122
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -60 13150 2 0 {name=p183 lab=VDD}
C {gnd.sym} -60 13280 2 0 {name=l122 lab=GND}
C {lab_pin.sym} -60 13250 2 0 {name=p184 lab=VDD}
C {gnd.sym} -60 13370 0 0 {name=l123 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} -60 13650 3 0 {name=M123
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -60 13470 1 0 {name=M124
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -60 13450 2 0 {name=p185 lab=VDD}
C {gnd.sym} -60 13580 2 0 {name=l124 lab=GND}
C {lab_pin.sym} -60 13550 2 0 {name=p186 lab=VDD}
C {gnd.sym} -60 13670 0 0 {name=l125 lab=GND}
C {sg13g2_stdcells/sg13g2_inv_1.sym} 250 12650 0 0 {name=x22 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 330 12650 0 0 {name=x23 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} -770 11840 0 0 {name=p187 lab=VDD}
C {gnd.sym} -770 12060 0 0 {name=l126 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} -770 13410 3 0 {name=M125
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -770 13230 1 0 {name=M126
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} -770 13340 2 0 {name=l127 lab=GND}
C {lab_pin.sym} -770 13310 2 0 {name=p188 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -770 13710 3 0 {name=M127
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -770 13530 1 0 {name=M128
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -770 13510 2 0 {name=p189 lab=VDD}
C {gnd.sym} -770 13640 2 0 {name=l128 lab=GND}
C {lab_pin.sym} -770 13610 2 0 {name=p190 lab=VDD}
C {gnd.sym} -770 13730 0 0 {name=l129 lab=GND}
C {lab_pin.sym} -800 13620 0 0 {name=p191 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -770 14010 3 0 {name=M129
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -770 13830 1 0 {name=M130
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -770 13810 2 0 {name=p192 lab=VDD}
C {gnd.sym} -770 13940 2 0 {name=l130 lab=GND}
C {lab_pin.sym} -770 13910 2 0 {name=p193 lab=VDD}
C {gnd.sym} -770 14030 0 0 {name=l131 lab=GND}
C {lab_pin.sym} -800 13920 0 0 {name=p194 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -770 14310 3 0 {name=M131
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -770 14130 1 0 {name=M132
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -770 14110 2 0 {name=p195 lab=VDD}
C {gnd.sym} -770 14240 2 0 {name=l132 lab=GND}
C {lab_pin.sym} -770 14210 2 0 {name=p196 lab=VDD}
C {gnd.sym} -770 14330 0 0 {name=l133 lab=GND}
C {lab_pin.sym} -800 14220 0 0 {name=p197 lab=VDD}
C {lab_pin.sym} -800 13320 0 0 {name=p198 lab=VDD}
C {lab_pin.sym} -770 13210 0 0 {name=p199 lab=VDD}
C {gnd.sym} -770 13430 0 0 {name=l134 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} -760 14830 3 0 {name=M133
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -760 14650 1 0 {name=M134
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} -760 14760 2 0 {name=l135 lab=GND}
C {lab_pin.sym} -760 14730 2 0 {name=p200 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -760 15130 3 0 {name=M135
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -760 14950 1 0 {name=M136
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -760 14930 2 0 {name=p201 lab=VDD}
C {gnd.sym} -760 15060 2 0 {name=l136 lab=GND}
C {lab_pin.sym} -760 15030 2 0 {name=p202 lab=VDD}
C {gnd.sym} -760 15150 0 0 {name=l137 lab=GND}
C {lab_pin.sym} -790 15040 0 0 {name=p203 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -760 15430 3 0 {name=M137
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -760 15250 1 0 {name=M138
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -760 15230 2 0 {name=p204 lab=VDD}
C {gnd.sym} -760 15360 2 0 {name=l138 lab=GND}
C {lab_pin.sym} -760 15330 2 0 {name=p205 lab=VDD}
C {gnd.sym} -760 15450 0 0 {name=l139 lab=GND}
C {lab_pin.sym} -790 15340 0 0 {name=p206 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -760 15730 3 0 {name=M139
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -760 15550 1 0 {name=M140
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -760 15530 2 0 {name=p207 lab=VDD}
C {gnd.sym} -760 15660 2 0 {name=l140 lab=GND}
C {lab_pin.sym} -760 15630 2 0 {name=p208 lab=VDD}
C {gnd.sym} -760 15750 0 0 {name=l141 lab=GND}
C {lab_pin.sym} -790 15640 0 0 {name=p209 lab=VDD}
C {lab_pin.sym} -790 14740 0 0 {name=p210 lab=VDD}
C {lab_pin.sym} -760 14630 0 0 {name=p211 lab=VDD}
C {gnd.sym} -760 14850 0 0 {name=l142 lab=GND}
C {sg13g2_stdcells/sg13g2_inv_1.sym} -520 11130 0 0 {name=x25 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} -520 12400 0 0 {name=x26 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} -520 13780 0 0 {name=x27 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} -510 15210 0 0 {name=x28 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} 170 12650 0 0 {name=x29 VDD=VDD VSS=VSS prefix=sg13g2_ }
