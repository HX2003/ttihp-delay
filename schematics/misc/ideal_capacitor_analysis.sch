** sch_path: schematics/misc/ideal_capacitor_analysis.sch
**.subckt ideal_capacitor_analysis
Isource GND gate 100u
C1 gate GND 1p m=1
**** begin user architecture code

  .lib $::MODELS_NGSPICE/cornerCAP.lib cap_typ
  .lib cornerMOSlv.lib mos_tt
  .lib cornerRES.lib res_typ



* Note! Since this script is wrapped in tcleval,
* code that is written in square brackets are in TCL scripting language
*
* The rest of the code is in spice scripting language

* Disabled because of computational cost/memory usage for big designs
* Save FET params like ids, gm, gds, vth, vgs, vdss, vds, cgg, cgsol, cgdol
* for annotation later (easier debugging and analysis)
.include [file rootname [file tail [xschem get current_name]]].save

* Customized code to include spice model for simulation

.include sg13g2_stdcell.spice
.options temp=25


* initial condition, gate is at 0V
* this is very important
.ic v(gate)=0

.control
  save all

  * initial condition, gate is at 0V
  tran 1p 10n

  let current = 100 * 1e-6

  let cap = current / deriv(v(gate))

  * While we can directly plot it in a popup, I instead save it,
  * and use the integrated graph inside the schematic
  * plot cap

  * no need to put save here, as save all saves everything
  * save cap

  write [file rootname [file tail [xschem get current_name]]].raw

  * I DID NOT USE THE BELOW, because if an error occured we wouldn't know
  * Automatically close the popup after simulation complete *
  * quit
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
