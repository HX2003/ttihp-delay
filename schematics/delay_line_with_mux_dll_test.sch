** sch_path: schematics/delay_line_with_mux_dll_test.sch
**.subckt delay_line_with_mux_dll_test
V2 VDD GND PWL(0ns 0 0.1ns 1.2)
V4 DLL_RESETN GND PWL(0ns 0 300ns 0 300.1ns 1.2)
V1 REF_CLK GND PULSE(0 1.2 5n 100p 100p 10ns 20ns)
x1 VDD DELAY_OUT GND DELAY_VBIASN DELAY_VBIASP REF_CLK DLL_RESETN GND GND MUX_OUT VDD GND GND
+ hx_delay_line_with_mux_dll
**** begin user architecture code






* Note! Since this script is wrapped in tcleval,
* code that is written in square brackets are in TCL scripting language
*
* The rest of the code is in spice scripting language

* Disabled because of computational cost/memory usage for big designs
* Save FET params like ids, gm, gds, vth, vgs, vdss, vds, cgg, cgsol, cgdol
* for annotation later (easier debugging and analysis)
* .include [file rootname [file tail [xschem get current_name]]].save

.options temp=25

[if {[info exists tcl_var_use_post_layout_netlist] && $tcl_var_use_post_layout_netlist == 1} {
  set prefix ".include "
  set middle [xschem get current_dirname]
  set suffix /build/spice_parasitics/dll_controller.pex.spice
  return $prefix$middle$suffix
}]

.control
  * save all is not suitable for large designs / long simulations
  * save all
  [if {[info exists tcl_var_use_post_layout_netlist] && $tcl_var_use_post_layout_netlist == 1} {
    return "
    * When using the post-layout netlist, some nets not accessible
    save v(DLL_RESETN) v(REF_CLK) v(DELAY_OUT) v(MUX_OUT) v(DELAY_VBIASP) v(DELAY_VBIASN) v(VDD)"
  } else {
    return "
    save v(DLL_RESETN) v(REF_CLK) v(DELAY_OUT) v(MUX_OUT) v(DELAY_VBIASP) v(DELAY_VBIASN) v(VDD)
    + v(x1.x1.up) v(x1.x1.down) i(x1.x1.vcharge) i(x1.x1.x3.vchargeup) i(x1.x1.x3.vchargedown)"
  }]

  *
  * 5p timestep seems insufficient *
  * but any lower than that fails to converge on my system at least with KLU solver *
  * thats why I used xyce *
  tran 5p 3000n

  write [file rootname [file tail [xschem get current_name]]].raw

  * I DID NOT USE THE BELOW, because if an error occured we wouldn't know
  * Automatically close the popup after simulation complete *
  * quit
.endc









.lib $::MODELS_NGSPICE/cornerMOSlv.lib mos_tt
.lib $::MODELS_NGSPICE/cornerRES.lib res_typ
.lib $::MODELS_NGSPICE/cornerCAP.lib cap_typ
*.include sg13g2_stdcell.spice



**** end user architecture code
**.ends
.GLOBAL GND
.end
