** sch_path: misc/mux4_delay_analysis.sch
**.subckt mux4_delay_analysis
XM12 sig2 VDD sig3 GND sg13_lv_nmos w=0.74u l=0.13u ng=1 m=1 mm_ok=1
XM15 sig2 GND sig3 VDD sg13_lv_pmos w=1.12u l=0.13u ng=1 m=1 mm_ok=1
V2 VDD GND PWL(0ns 0 0.1ns 1.2)
V1 in GND PWL(0ns 0 1ns 0 1.1ns 1.2)
XM1 VDD GND sig3 GND sg13_lv_nmos w=0.74u l=0.13u ng=1 m=1 mm_ok=1
XM2 VDD VDD sig3 VDD sg13_lv_pmos w=1.12u l=0.13u ng=1 m=1 mm_ok=1
XM3 VDD GND sig3 GND sg13_lv_nmos w=0.74u l=0.13u ng=1 m=1 mm_ok=1
XM4 VDD VDD sig3 VDD sg13_lv_pmos w=1.12u l=0.13u ng=1 m=1 mm_ok=1
XM5 VDD GND sig3 GND sg13_lv_nmos w=0.74u l=0.13u ng=1 m=1 mm_ok=1
XM6 VDD VDD sig3 VDD sg13_lv_pmos w=1.12u l=0.13u ng=1 m=1 mm_ok=1
x32 net7 in VDD VSS sg13g2_inv_1
x1 sig2 net7 VDD VSS sg13g2_inv_1
x2 net8 sig3 VDD VSS sg13g2_inv_1
x3 out_transgatemux4_1 net8 VDD VSS sg13g2_inv_1
R1 GND VSS 0.00001 m=1
x4 net9 in VDD VSS sg13g2_inv_1
x5 net1 net9 VDD VSS sg13g2_inv_1
x6 net10 net1 VDD VSS sg13g2_inv_1
x7 out_nomux net10 VDD VSS sg13g2_inv_1
x24 net3 net2 VDD VDD VDD GND GND VDD VSS sg13g2_mux4_1
x8 net11 in VDD VSS sg13g2_inv_1
x9 net2 net11 VDD VSS sg13g2_inv_1
x10 net12 net3 VDD VSS sg13g2_inv_1
x11 out_standardcellmux4_1 net12 VDD VSS sg13g2_inv_1
XM7 net5 VDD net4 GND sg13_lv_nmos w=0.74u l=0.13u ng=1 m=1 mm_ok=1
XM8 net5 GND net4 VDD sg13_lv_pmos w=1.12u l=0.13u ng=1 m=1 mm_ok=1
x12 net13 in VDD VSS sg13g2_inv_1
x13 net5 net13 VDD VSS sg13g2_inv_1
XM9 VDD GND net4 GND sg13_lv_nmos w=0.74u l=0.13u ng=1 m=1 mm_ok=1
XM10 VDD VDD net4 VDD sg13_lv_pmos w=1.12u l=0.13u ng=1 m=1 mm_ok=1
XM11 VDD VDD VDD GND sg13_lv_nmos w=0.74u l=0.13u ng=1 m=1 mm_ok=1
XM13 VDD VDD VDD VDD sg13_lv_pmos w=1.12u l=0.13u ng=1 m=1 mm_ok=1
XM14 VDD GND VDD GND sg13_lv_nmos w=0.74u l=0.13u ng=1 m=1 mm_ok=1
XM16 VDD VDD VDD VDD sg13_lv_pmos w=1.12u l=0.13u ng=1 m=1 mm_ok=1
XM17 net4 VDD net6 GND sg13_lv_nmos w=0.74u l=0.13u ng=1 m=1 mm_ok=1
XM18 net4 GND net6 VDD sg13_lv_pmos w=1.12u l=0.13u ng=1 m=1 mm_ok=1
XM19 VDD GND net6 GND sg13_lv_nmos w=0.74u l=0.13u ng=1 m=1 mm_ok=1
XM20 VDD VDD net6 VDD sg13_lv_pmos w=1.12u l=0.13u ng=1 m=1 mm_ok=1
x14 net14 net6 VDD VSS sg13g2_inv_1
x15 out_transgatemuxtree2_1 net14 VDD VSS sg13g2_inv_1
**** begin user architecture code

  .lib $::MODELS_NGSPICE/cornerCAP.lib cap_typ
  .lib cornerMOSlv.lib mos_tt
  .lib cornerRES.lib res_typ



* Note! Since this script is wrapped in tcleval,
* code that is written in square brackets are in TCL scripting language
*
* The rest of the code is in spice scripting language

* Disabled because of computational cost/memory usage for big designs
* Save FET params like ids, gm, gds, vth, vgs, vdss, vds, cgg, cgsol, cgdol
* for annotation later (easier debugging and analysis)
.include [file rootname [file tail [xschem get current_name]]].save

* Customized code to include spice model for simulation

.include sg13g2_stdcell.spice
.options temp=25


.control
  save all

  tran 1p 2n

  write [file rootname [file tail [xschem get current_name]]].raw

  * I DID NOT USE THE BELOW, because if an error occured we wouldn't know
  * Automatically close the popup after simulation complete *
  * quit
.endc


**** end user architecture code
**.ends

* expanding   symbol:  sg13g2_stdcells/sg13g2_inv_1.sym # of pins=2
** sym_path: sg13g2_stdcells/sg13g2_inv_1.sym
** sch_path: sg13g2_stdcells/sg13g2_inv_1.sch
.subckt sg13g2_inv_1 Y A VDD VSS
*.opin Y
*.ipin A
*.iopin VDD
*.iopin VSS
XM1 Y A VSS VSS sg13_lv_nmos w=740.00n l=130.00n ng=1 m=1 mm_ok=1
XM2 Y A VDD VDD sg13_lv_pmos w=1.12u l=130.00n ng=1 m=1 mm_ok=1
.ends


* expanding   symbol:  sg13g2_stdcells/sg13g2_mux4_1.sym # of pins=7
** sym_path: sg13g2_stdcells/sg13g2_mux4_1.sym
** sch_path: sg13g2_stdcells/sg13g2_mux4_1.sch
.subckt sg13g2_mux4_1 X A0 A1 A2 A3 S0 S1 VDD VSS
*.ipin S0
*.ipin S1
*.iopin VSS
*.ipin A0
*.ipin A1
*.ipin A2
*.ipin A3
*.opin X
*.iopin VDD
XM1 S0b S0 VSS VSS sg13_lv_nmos w=640.00n l=130.00n ng=1 m=1 mm_ok=1
XM2 S1b S1 VSS VSS sg13_lv_nmos w=640.00n l=130.00n ng=1 m=1 mm_ok=1
XM3 net4 A3 VSS VSS sg13_lv_nmos w=640.00n l=130.00n ng=1 m=1 mm_ok=1
XM4 high S1 Xb VSS sg13_lv_nmos w=640.00n l=130.00n ng=1 m=1 mm_ok=1
XM5 X Xb VSS VSS sg13_lv_nmos w=740.00n l=130.00n ng=1 m=1 mm_ok=1
XM6 low S0b net7 VSS sg13_lv_nmos w=640.00n l=130.00n ng=1 m=1 mm_ok=1
XM7 net7 A0 VSS VSS sg13_lv_nmos w=640.00n l=130.00n ng=1 m=1 mm_ok=1
XM8 low S0 net2 VSS sg13_lv_nmos w=640.00n l=130.00n ng=1 m=1 mm_ok=1
XM9 net2 A1 VSS VSS sg13_lv_nmos w=640.00n l=130.00n ng=1 m=1 mm_ok=1
XM10 low S1b Xb VSS sg13_lv_nmos w=640.00n l=130.00n ng=1 m=1 mm_ok=1
XM11 high S0b net6 VSS sg13_lv_nmos w=640.00n l=130.00n ng=1 m=1 mm_ok=1
XM12 net6 A2 VSS VSS sg13_lv_nmos w=640.00n l=130.00n ng=1 m=1 mm_ok=1
XM13 high S0 net4 VSS sg13_lv_nmos w=640.00n l=130.00n ng=1 m=1 mm_ok=1
XM14 S0b S0 VDD VDD sg13_lv_pmos w=1.000u l=130.00n ng=1 m=1 mm_ok=1
XM15 S1b S1 VDD VDD sg13_lv_pmos w=1.000u l=130.00n ng=1 m=1 mm_ok=1
XM16 high S0b net3 VDD sg13_lv_pmos w=1.000u l=130.00n ng=1 m=1 mm_ok=1
XM17 high S1b Xb VDD sg13_lv_pmos w=1.000u l=130.00n ng=1 m=1 mm_ok=1
XM18 X Xb VDD VDD sg13_lv_pmos w=1.12u l=130.00n ng=1 m=1 mm_ok=1
XM19 net8 A0 VDD VDD sg13_lv_pmos w=1.000u l=130.00n ng=1 m=1 mm_ok=1
XM20 low S0 net8 VDD sg13_lv_pmos w=1.000u l=130.00n ng=1 m=1 mm_ok=1
XM21 net1 A1 VDD VDD sg13_lv_pmos w=1.000u l=130.00n ng=1 m=1 mm_ok=1
XM22 low S0b net1 VDD sg13_lv_pmos w=1.000u l=130.00n ng=1 m=1 mm_ok=1
XM23 low S1 Xb VDD sg13_lv_pmos w=1.000u l=130.00n ng=1 m=1 mm_ok=1
XM24 net5 A2 VDD VDD sg13_lv_pmos w=1.000u l=130.00n ng=1 m=1 mm_ok=1
XM25 high S0 net5 VDD sg13_lv_pmos w=1.000u l=130.00n ng=1 m=1 mm_ok=1
XM26 net3 A3 VDD VDD sg13_lv_pmos w=1.000u l=130.00n ng=1 m=1 mm_ok=1
.ends

.GLOBAL GND
.end
