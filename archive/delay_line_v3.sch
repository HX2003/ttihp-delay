v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
B 2 -10 -1540 790 -1140 {flags=graph
y1=-1.2183179
y2=1.2727308
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9101639e-05
x2=1.9165214e-05
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color="21 8 5"
node="out
in
vdd"
divx=5
hilight_wave=0}
B 2 -10 -1970 790 -1570 {flags=graph
y1=-0.32531444
y2=1.6675244
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9101639e-05
x2=1.9165214e-05
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
divx=5
color="4 7"
node="up
down"}
B 2 -10 -2410 790 -2010 {flags=graph
y1=-0.27153961
y2=1.2589606
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9101639e-05
x2=1.9165214e-05
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
divx=5
color=20
node=VCtrl}
B 2 -10 -2840 790 -2440 {flags=graph
y1=-0.72010816
y2=1.7709405
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9101639e-05
x2=1.9165214e-05
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color="8 21"
node="delaycheckin
delaycheckout"
divx=5
hilight_wave=0}
B 2 -10 -3270 790 -2870 {flags=graph
y1=-0.27153961
y2=1.2589606
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.9101639e-05
x2=1.9165214e-05
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
divx=5
color=20
node=rstn}
T {Ctrl-Click to execute launcher} 10 -1120 0 0 0.3 0.3 {layer=11}
T {The system should be initialized in reset state,
in which the loop capacitor is to be charged to 1.2V.

The active low reset signal, which initially is at 0V, will be set to 1.2V after 100ns.
} -2350 -830 0 0 0.6 0.6 {}
N -1920 -250 -1920 -170 {lab=VDD}
N -1960 -170 -1960 -110 {lab=#net1}
N -1920 -110 -1920 -50 {lab=#net1}
N -1960 -110 -1920 -110 {lab=#net1}
N -1920 -140 -1920 -110 {lab=#net1}
N -1920 10 -1920 230 {lab=#net2}
N -1920 260 -1920 310 {lab=GND}
N -1960 190 -1960 260 {lab=VCtrl}
N -1970 30 -1970 50 {lab=in}
N -2790 170 -2790 240 {lab=#net3}
N -2040 260 -1960 260 {lab=VCtrl}
N -2890 0 -2830 0 {lab=#net4}
N -2600 70 -2560 70 {lab=VCtrl}
N -2790 70 -2790 110 {lab=VCtrl}
N -2790 -90 -2790 -30 {lab=#net5}
N -2790 -170 -2790 -120 {lab=VDD}
N -2790 0 -2710 -90 {lab=VDD}
N -2790 -170 -2710 -90 {lab=VDD}
N -2790 140 -2700 220 {lab=GND}
N -2790 300 -2700 220 {lab=GND}
N -3630 60 -3630 120 {lab=#net6}
N -3630 60 -3400 60 {lab=#net6}
N -3630 0 -3630 60 {lab=#net6}
N -3450 -40 -3280 -40 {lab=up}
N -3450 160 -3280 160 {lab=down}
N -2790 270 -2790 300 {lab=GND}
N -2990 270 -2830 270 {lab=#net7}
N -3040 270 -3040 300 {lab=GND}
N -3040 300 -2790 300 {lab=GND}
N -3080 230 -3080 270 {lab=#net7}
N -3080 230 -3040 230 {lab=#net7}
N -3040 230 -3040 240 {lab=#net7}
N -3040 230 -2990 230 {lab=#net7}
N -2990 230 -2990 270 {lab=#net7}
N -3050 -110 -3050 -80 {lab=#net8}
N -3010 -170 -3010 -110 {lab=VDD}
N -3010 -170 -2790 -170 {lab=VDD}
N -2830 -120 -2830 -80 {lab=#net8}
N -3050 -80 -2830 -80 {lab=#net8}
N -1600 990 -1570 990 {
lab=#net9}
N -1600 890 -1570 890 {
lab=#net9}
N -1600 940 -1600 990 {
lab=#net9}
N -1710 990 -1660 990 {
lab=GND}
N -1710 890 -1660 890 {
lab=VDD}
N -1710 940 -1710 960 {
lab=#net9}
N -1780 990 -1750 990 {
lab=delaycheckin}
N -1780 890 -1750 890 {
lab=delaycheckin}
N -1710 920 -1710 940 {
lab=#net9}
N -1710 940 -1600 940 {
lab=#net9}
N -1600 890 -1600 940 {
lab=#net9}
N -1780 940 -1780 990 {
lab=delaycheckin}
N -1660 990 -1660 1220 {
lab=GND}
N -1710 1020 -1710 1140 {
lab=#net10}
N -1660 660 -1530 660 {lab=VDD}
N -1710 660 -1710 740 {lab=VDD}
N -1530 660 -1530 890 {lab=VDD}
N -1750 740 -1750 800 {lab=#net11}
N -1750 1100 -1750 1170 {lab=VCtrl}
N -1920 660 -1920 740 {lab=VDD}
N -1960 740 -1960 800 {lab=#net11}
N -1920 660 -1710 660 {lab=VDD}
N -1920 1220 -1710 1220 {lab=GND}
N -1920 800 -1920 860 {lab=#net11}
N -1960 800 -1920 800 {lab=#net11}
N -1920 770 -1920 800 {lab=#net11}
N -1920 800 -1750 800 {lab=#net11}
N -1920 920 -1920 1140 {lab=#net12}
N -1710 770 -1710 860 {lab=#net13}
N -1710 1170 -1710 1220 {lab=GND}
N -1920 1170 -1920 1220 {lab=GND}
N -1660 660 -1660 890 {lab=VDD}
N -1710 660 -1660 660 {lab=VDD}
N -1710 1220 -1660 1220 {lab=GND}
N -1960 1100 -1750 1100 {lab=VCtrl}
N -1960 1100 -1960 1170 {lab=VCtrl}
N -1970 940 -1780 940 {lab=delaycheckin}
N -1970 940 -1970 960 {lab=delaycheckin}
N -1780 890 -1780 940 {
lab=delaycheckin}
N -1530 940 -1530 960 {
lab=#net14}
N -1530 990 -1530 1220 {lab=GND}
N -1660 1220 -1530 1220 {lab=GND}
N -2040 1170 -1960 1170 {lab=VCtrl}
N -2050 660 -1920 660 {lab=VDD}
N -1440 990 -1410 990 {
lab=#net14}
N -1440 890 -1410 890 {
lab=#net14}
N -1440 940 -1440 990 {
lab=#net14}
N -1440 890 -1440 940 {
lab=#net14}
N -1370 660 -1370 890 {lab=VDD}
N -1370 940 -1370 960 {
lab=#net15}
N -1370 990 -1370 1220 {lab=GND}
N -1530 940 -1440 940 {lab=#net14}
N -1530 920 -1530 940 {
lab=#net14}
N -1530 1220 -1370 1220 {lab=GND}
N -1530 660 -1370 660 {lab=VDD}
N -1000 990 -970 990 {
lab=#net16}
N -1000 890 -970 890 {
lab=#net16}
N -1000 940 -1000 990 {
lab=#net16}
N -1110 990 -1060 990 {
lab=GND}
N -1110 890 -1060 890 {
lab=VDD}
N -1110 940 -1110 960 {
lab=#net16}
N -1180 990 -1150 990 {
lab=#net15}
N -1180 890 -1150 890 {
lab=#net15}
N -1110 920 -1110 940 {
lab=#net16}
N -1110 940 -1000 940 {
lab=#net16}
N -1000 890 -1000 940 {
lab=#net16}
N -1180 940 -1180 990 {
lab=#net15}
N -1060 990 -1060 1220 {
lab=GND}
N -1110 1020 -1110 1140 {
lab=#net17}
N -1060 660 -930 660 {lab=VDD}
N -1110 660 -1110 740 {lab=VDD}
N -930 660 -930 890 {lab=VDD}
N -1150 740 -1150 800 {lab=#net11}
N -1150 1100 -1150 1170 {lab=VCtrl}
N -1370 1220 -1110 1220 {lab=GND}
N -1110 770 -1110 860 {lab=#net18}
N -1110 1170 -1110 1220 {lab=GND}
N -1060 660 -1060 890 {lab=VDD}
N -1110 660 -1060 660 {lab=VDD}
N -1110 1220 -1060 1220 {lab=GND}
N -1370 940 -1180 940 {lab=#net15}
N -1180 890 -1180 940 {
lab=#net15}
N -930 940 -930 960 {
lab=#net19}
N -930 990 -930 1220 {lab=GND}
N -1060 1220 -930 1220 {lab=GND}
N -840 990 -810 990 {
lab=#net19}
N -840 890 -810 890 {
lab=#net19}
N -840 940 -840 990 {
lab=#net19}
N -840 890 -840 940 {
lab=#net19}
N -770 660 -770 890 {lab=VDD}
N -770 940 -770 960 {
lab=#net20}
N -770 990 -770 1220 {lab=GND}
N -930 940 -840 940 {lab=#net19}
N -930 920 -930 940 {
lab=#net19}
N -930 1220 -770 1220 {lab=GND}
N -930 660 -770 660 {lab=VDD}
N -1370 920 -1370 940 {
lab=#net15}
N -1750 800 -1150 800 {lab=#net11}
N -1750 1100 -1150 1100 {lab=VCtrl}
N -1370 660 -1110 660 {lab=VDD}
N -400 990 -370 990 {
lab=#net21}
N -400 890 -370 890 {
lab=#net21}
N -400 940 -400 990 {
lab=#net21}
N -510 990 -460 990 {
lab=GND}
N -510 890 -460 890 {
lab=VDD}
N -510 940 -510 960 {
lab=#net21}
N -580 990 -550 990 {
lab=#net20}
N -580 890 -550 890 {
lab=#net20}
N -510 920 -510 940 {
lab=#net21}
N -510 940 -400 940 {
lab=#net21}
N -400 890 -400 940 {
lab=#net21}
N -580 940 -580 990 {
lab=#net20}
N -460 990 -460 1220 {
lab=GND}
N -510 1020 -510 1140 {
lab=#net22}
N -460 660 -330 660 {lab=VDD}
N -510 660 -510 740 {lab=VDD}
N -330 660 -330 890 {lab=VDD}
N -550 740 -550 800 {lab=#net11}
N -550 1100 -550 1170 {lab=VCtrl}
N -770 1220 -510 1220 {lab=GND}
N -510 770 -510 860 {lab=#net23}
N -510 1170 -510 1220 {lab=GND}
N -460 660 -460 890 {lab=VDD}
N -510 660 -460 660 {lab=VDD}
N -510 1220 -460 1220 {lab=GND}
N -770 940 -580 940 {lab=#net20}
N -580 890 -580 940 {
lab=#net20}
N -330 940 -330 960 {
lab=#net24}
N -330 990 -330 1220 {lab=GND}
N -460 1220 -330 1220 {lab=GND}
N -240 990 -210 990 {
lab=#net24}
N -240 890 -210 890 {
lab=#net24}
N -240 940 -240 990 {
lab=#net24}
N -240 890 -240 940 {
lab=#net24}
N -170 660 -170 890 {lab=VDD}
N -170 940 -170 960 {
lab=#net25}
N -170 990 -170 1220 {lab=GND}
N -330 940 -240 940 {lab=#net24}
N -330 920 -330 940 {
lab=#net24}
N -330 1220 -170 1220 {lab=GND}
N -330 660 -170 660 {lab=VDD}
N 200 990 230 990 {
lab=#net26}
N 200 890 230 890 {
lab=#net26}
N 200 940 200 990 {
lab=#net26}
N 90 990 140 990 {
lab=GND}
N 90 890 140 890 {
lab=VDD}
N 90 940 90 960 {
lab=#net26}
N 20 990 50 990 {
lab=#net25}
N 20 890 50 890 {
lab=#net25}
N 90 920 90 940 {
lab=#net26}
N 90 940 200 940 {
lab=#net26}
N 200 890 200 940 {
lab=#net26}
N 20 940 20 990 {
lab=#net25}
N 140 990 140 1220 {
lab=GND}
N 90 1020 90 1140 {
lab=#net27}
N 140 660 270 660 {lab=VDD}
N 90 660 90 740 {lab=VDD}
N 270 660 270 890 {lab=VDD}
N 50 740 50 800 {lab=#net11}
N 50 1100 50 1170 {lab=VCtrl}
N -170 1220 90 1220 {lab=GND}
N 90 770 90 860 {lab=#net28}
N 90 1170 90 1220 {lab=GND}
N 140 660 140 890 {lab=VDD}
N 90 660 140 660 {lab=VDD}
N 90 1220 140 1220 {lab=GND}
N -170 940 20 940 {lab=#net25}
N 20 890 20 940 {
lab=#net25}
N 270 940 270 960 {
lab=#net29}
N 270 990 270 1220 {lab=GND}
N 140 1220 270 1220 {lab=GND}
N 360 990 390 990 {
lab=#net29}
N 360 890 390 890 {
lab=#net29}
N 360 940 360 990 {
lab=#net29}
N 360 890 360 940 {
lab=#net29}
N 430 660 430 890 {lab=VDD}
N 430 940 430 960 {
lab=#net30}
N 430 990 430 1220 {lab=GND}
N 270 940 360 940 {lab=#net29}
N 270 920 270 940 {
lab=#net29}
N 270 660 430 660 {lab=VDD}
N -170 920 -170 940 {
lab=#net25}
N -550 800 50 800 {lab=#net11}
N -550 1100 50 1100 {lab=VCtrl}
N -170 660 90 660 {lab=VDD}
N -770 920 -770 940 {
lab=#net20}
N -1150 800 -550 800 {lab=#net11}
N -1150 1100 -550 1100 {lab=VCtrl}
N -770 660 -510 660 {lab=VDD}
N 270 1220 430 1220 {lab=GND}
N -1590 80 -1560 80 {
lab=#net31}
N -1590 -20 -1560 -20 {
lab=#net31}
N -1590 30 -1590 80 {
lab=#net31}
N -1700 80 -1650 80 {
lab=GND}
N -1700 -20 -1650 -20 {
lab=VDD}
N -1700 30 -1700 50 {
lab=#net31}
N -1770 80 -1740 80 {
lab=in}
N -1770 -20 -1740 -20 {
lab=in}
N -1700 10 -1700 30 {
lab=#net31}
N -1700 30 -1590 30 {
lab=#net31}
N -1590 -20 -1590 30 {
lab=#net31}
N -1770 30 -1770 80 {
lab=in}
N -1650 80 -1650 310 {
lab=GND}
N -1700 110 -1700 230 {
lab=#net32}
N -1650 -250 -1520 -250 {lab=VDD}
N -1700 -250 -1700 -170 {lab=VDD}
N -1520 -250 -1520 -20 {lab=VDD}
N -1740 -170 -1740 -110 {lab=#net1}
N -1740 190 -1740 260 {lab=VCtrl}
N -1700 310 -1650 310 {lab=GND}
N -1700 -140 -1700 -50 {lab=#net33}
N -1700 260 -1700 310 {lab=GND}
N -1650 -250 -1650 -20 {lab=VDD}
N -1700 -250 -1650 -250 {lab=VDD}
N -1770 -20 -1770 30 {
lab=in}
N -1520 30 -1520 50 {
lab=#net34}
N -1520 80 -1520 310 {lab=GND}
N -1650 310 -1520 310 {lab=GND}
N -1430 80 -1400 80 {
lab=#net34}
N -1430 -20 -1400 -20 {
lab=#net34}
N -1430 30 -1430 80 {
lab=#net34}
N -1430 -20 -1430 30 {
lab=#net34}
N -1360 -250 -1360 -20 {lab=VDD}
N -1360 30 -1360 50 {
lab=#net35}
N -1360 80 -1360 310 {lab=GND}
N -1520 30 -1430 30 {lab=#net34}
N -1520 10 -1520 30 {
lab=#net34}
N -1520 310 -1360 310 {lab=GND}
N -1520 -250 -1360 -250 {lab=VDD}
N -990 80 -960 80 {
lab=#net36}
N -990 -20 -960 -20 {
lab=#net36}
N -990 30 -990 80 {
lab=#net36}
N -1100 80 -1050 80 {
lab=GND}
N -1100 -20 -1050 -20 {
lab=VDD}
N -1100 30 -1100 50 {
lab=#net36}
N -1170 80 -1140 80 {
lab=#net35}
N -1170 -20 -1140 -20 {
lab=#net35}
N -1100 10 -1100 30 {
lab=#net36}
N -1100 30 -990 30 {
lab=#net36}
N -990 -20 -990 30 {
lab=#net36}
N -1170 30 -1170 80 {
lab=#net35}
N -1050 80 -1050 310 {
lab=GND}
N -1100 110 -1100 230 {
lab=#net37}
N -1050 -250 -920 -250 {lab=VDD}
N -1100 -250 -1100 -170 {lab=VDD}
N -920 -250 -920 -20 {lab=VDD}
N -1140 -170 -1140 -110 {lab=#net1}
N -1140 190 -1140 260 {lab=VCtrl}
N -1360 310 -1100 310 {lab=GND}
N -1100 -140 -1100 -50 {lab=#net38}
N -1100 260 -1100 310 {lab=GND}
N -1050 -250 -1050 -20 {lab=VDD}
N -1100 -250 -1050 -250 {lab=VDD}
N -1100 310 -1050 310 {lab=GND}
N -1360 30 -1170 30 {lab=#net35}
N -1170 -20 -1170 30 {
lab=#net35}
N -920 30 -920 50 {
lab=#net39}
N -920 80 -920 310 {lab=GND}
N -1050 310 -920 310 {lab=GND}
N -830 80 -800 80 {
lab=#net39}
N -830 -20 -800 -20 {
lab=#net39}
N -830 30 -830 80 {
lab=#net39}
N -830 -20 -830 30 {
lab=#net39}
N -760 -250 -760 -20 {lab=VDD}
N -760 30 -760 50 {
lab=#net40}
N -760 80 -760 310 {lab=GND}
N -920 30 -830 30 {lab=#net39}
N -920 10 -920 30 {
lab=#net39}
N -920 310 -760 310 {lab=GND}
N -920 -250 -760 -250 {lab=VDD}
N -1360 10 -1360 30 {
lab=#net35}
N -1740 -110 -1140 -110 {lab=#net1}
N -1740 190 -1140 190 {lab=VCtrl}
N -1360 -250 -1100 -250 {lab=VDD}
N -390 80 -360 80 {
lab=#net41}
N -390 -20 -360 -20 {
lab=#net41}
N -390 30 -390 80 {
lab=#net41}
N -500 80 -450 80 {
lab=GND}
N -500 -20 -450 -20 {
lab=VDD}
N -500 30 -500 50 {
lab=#net41}
N -570 80 -540 80 {
lab=#net40}
N -570 -20 -540 -20 {
lab=#net40}
N -500 10 -500 30 {
lab=#net41}
N -500 30 -390 30 {
lab=#net41}
N -390 -20 -390 30 {
lab=#net41}
N -570 30 -570 80 {
lab=#net40}
N -450 80 -450 310 {
lab=GND}
N -500 110 -500 230 {
lab=#net42}
N -450 -250 -320 -250 {lab=VDD}
N -500 -250 -500 -170 {lab=VDD}
N -320 -250 -320 -20 {lab=VDD}
N -540 -170 -540 -110 {lab=#net1}
N -540 190 -540 260 {lab=VCtrl}
N -760 310 -500 310 {lab=GND}
N -500 -140 -500 -50 {lab=#net43}
N -500 260 -500 310 {lab=GND}
N -450 -250 -450 -20 {lab=VDD}
N -500 -250 -450 -250 {lab=VDD}
N -500 310 -450 310 {lab=GND}
N -760 30 -570 30 {lab=#net40}
N -570 -20 -570 30 {
lab=#net40}
N -320 30 -320 50 {
lab=#net44}
N -320 80 -320 310 {lab=GND}
N -450 310 -320 310 {lab=GND}
N -230 80 -200 80 {
lab=#net44}
N -230 -20 -200 -20 {
lab=#net44}
N -230 30 -230 80 {
lab=#net44}
N -230 -20 -230 30 {
lab=#net44}
N -160 -250 -160 -20 {lab=VDD}
N -160 30 -160 50 {
lab=#net45}
N -160 80 -160 310 {lab=GND}
N -320 30 -230 30 {lab=#net44}
N -320 10 -320 30 {
lab=#net44}
N -320 310 -160 310 {lab=GND}
N -320 -250 -160 -250 {lab=VDD}
N 210 80 240 80 {
lab=#net46}
N 210 -20 240 -20 {
lab=#net46}
N 210 30 210 80 {
lab=#net46}
N 100 80 150 80 {
lab=GND}
N 100 -20 150 -20 {
lab=VDD}
N 100 30 100 50 {
lab=#net46}
N 30 80 60 80 {
lab=#net45}
N 30 -20 60 -20 {
lab=#net45}
N 100 10 100 30 {
lab=#net46}
N 100 30 210 30 {
lab=#net46}
N 210 -20 210 30 {
lab=#net46}
N 30 30 30 80 {
lab=#net45}
N 150 80 150 310 {
lab=GND}
N 100 110 100 230 {
lab=#net47}
N 150 -250 280 -250 {lab=VDD}
N 100 -250 100 -170 {lab=VDD}
N 280 -250 280 -20 {lab=VDD}
N 60 -170 60 -110 {lab=#net1}
N 60 190 60 260 {lab=VCtrl}
N -160 310 100 310 {lab=GND}
N 100 -140 100 -50 {lab=#net48}
N 100 260 100 310 {lab=GND}
N 150 -250 150 -20 {lab=VDD}
N 100 -250 150 -250 {lab=VDD}
N 100 310 150 310 {lab=GND}
N -160 30 30 30 {lab=#net45}
N 30 -20 30 30 {
lab=#net45}
N 280 30 280 50 {
lab=#net49}
N 280 80 280 310 {lab=GND}
N 150 310 280 310 {lab=GND}
N 370 80 400 80 {
lab=#net49}
N 370 -20 400 -20 {
lab=#net49}
N 370 30 370 80 {
lab=#net49}
N 370 -20 370 30 {
lab=#net49}
N 440 -250 440 -20 {lab=VDD}
N 440 30 440 50 {
lab=#net50}
N 440 80 440 310 {lab=GND}
N 280 30 370 30 {lab=#net49}
N 280 10 280 30 {
lab=#net49}
N 280 -250 440 -250 {lab=VDD}
N -160 10 -160 30 {
lab=#net45}
N -540 -110 60 -110 {lab=#net1}
N -540 190 60 190 {lab=VCtrl}
N -160 -250 100 -250 {lab=VDD}
N -760 10 -760 30 {
lab=#net40}
N -1140 -110 -540 -110 {lab=#net1}
N -1140 190 -540 190 {lab=VCtrl}
N -760 -250 -500 -250 {lab=VDD}
N 280 310 440 310 {lab=GND}
N -1970 30 -1770 30 {lab=in}
N -1920 -110 -1740 -110 {lab=#net1}
N -1920 -250 -1700 -250 {lab=VDD}
N -1960 190 -1740 190 {lab=VCtrl}
N -1920 310 -1700 310 {lab=GND}
N -1970 -110 -1960 -110 {lab=#net1}
N -2050 -250 -1920 -250 {lab=VDD}
N 800 990 830 990 {
lab=#net51}
N 800 890 830 890 {
lab=#net51}
N 800 940 800 990 {
lab=#net51}
N 690 990 740 990 {
lab=GND}
N 690 890 740 890 {
lab=VDD}
N 690 940 690 960 {
lab=#net51}
N 620 990 650 990 {
lab=#net30}
N 620 890 650 890 {
lab=#net30}
N 690 920 690 940 {
lab=#net51}
N 690 940 800 940 {
lab=#net51}
N 800 890 800 940 {
lab=#net51}
N 620 940 620 990 {
lab=#net30}
N 740 990 740 1220 {
lab=GND}
N 690 1020 690 1140 {
lab=#net52}
N 740 660 870 660 {lab=VDD}
N 690 660 690 740 {lab=VDD}
N 870 660 870 890 {lab=VDD}
N 650 740 650 800 {lab=#net11}
N 650 1100 650 1170 {lab=VCtrl}
N 690 770 690 860 {lab=#net53}
N 690 1170 690 1220 {lab=GND}
N 740 660 740 890 {lab=VDD}
N 690 660 740 660 {lab=VDD}
N 690 1220 740 1220 {lab=GND}
N 430 940 620 940 {lab=#net30}
N 620 890 620 940 {
lab=#net30}
N 870 940 870 960 {
lab=#net54}
N 870 990 870 1220 {lab=GND}
N 740 1220 870 1220 {lab=GND}
N 960 990 990 990 {
lab=#net54}
N 960 890 990 890 {
lab=#net54}
N 960 940 960 990 {
lab=#net54}
N 960 890 960 940 {
lab=#net54}
N 1030 660 1030 890 {lab=VDD}
N 1030 940 1030 960 {
lab=#net55}
N 1030 990 1030 1220 {lab=GND}
N 870 940 960 940 {lab=#net54}
N 870 920 870 940 {
lab=#net54}
N 870 1220 1030 1220 {lab=GND}
N 870 660 1030 660 {lab=VDD}
N 1400 990 1430 990 {
lab=#net56}
N 1400 890 1430 890 {
lab=#net56}
N 1400 940 1400 990 {
lab=#net56}
N 1290 990 1340 990 {
lab=GND}
N 1290 890 1340 890 {
lab=VDD}
N 1290 940 1290 960 {
lab=#net56}
N 1220 990 1250 990 {
lab=#net55}
N 1220 890 1250 890 {
lab=#net55}
N 1290 920 1290 940 {
lab=#net56}
N 1290 940 1400 940 {
lab=#net56}
N 1400 890 1400 940 {
lab=#net56}
N 1220 940 1220 990 {
lab=#net55}
N 1340 990 1340 1220 {
lab=GND}
N 1290 1020 1290 1140 {
lab=#net57}
N 1340 660 1470 660 {lab=VDD}
N 1290 660 1290 740 {lab=VDD}
N 1470 660 1470 890 {lab=VDD}
N 1250 740 1250 800 {lab=#net11}
N 1250 1100 1250 1170 {lab=VCtrl}
N 1030 1220 1290 1220 {lab=GND}
N 1290 770 1290 860 {lab=#net58}
N 1290 1170 1290 1220 {lab=GND}
N 1340 660 1340 890 {lab=VDD}
N 1290 660 1340 660 {lab=VDD}
N 1290 1220 1340 1220 {lab=GND}
N 1030 940 1220 940 {lab=#net55}
N 1220 890 1220 940 {
lab=#net55}
N 1470 940 1470 960 {
lab=#net59}
N 1470 990 1470 1220 {lab=GND}
N 1340 1220 1470 1220 {lab=GND}
N 1560 990 1590 990 {
lab=#net59}
N 1560 890 1590 890 {
lab=#net59}
N 1560 940 1560 990 {
lab=#net59}
N 1560 890 1560 940 {
lab=#net59}
N 1630 660 1630 890 {lab=VDD}
N 1630 940 1630 960 {
lab=#net60}
N 1630 990 1630 1220 {lab=GND}
N 1470 940 1560 940 {lab=#net59}
N 1470 920 1470 940 {
lab=#net59}
N 1470 1220 1630 1220 {lab=GND}
N 1470 660 1630 660 {lab=VDD}
N 1030 920 1030 940 {
lab=#net55}
N 650 800 1250 800 {lab=#net11}
N 650 1100 1250 1100 {lab=VCtrl}
N 1030 660 1290 660 {lab=VDD}
N 2000 990 2030 990 {
lab=#net61}
N 2000 890 2030 890 {
lab=#net61}
N 2000 940 2000 990 {
lab=#net61}
N 1890 990 1940 990 {
lab=GND}
N 1890 890 1940 890 {
lab=VDD}
N 1890 940 1890 960 {
lab=#net61}
N 1820 990 1850 990 {
lab=#net60}
N 1820 890 1850 890 {
lab=#net60}
N 1890 920 1890 940 {
lab=#net61}
N 1890 940 2000 940 {
lab=#net61}
N 2000 890 2000 940 {
lab=#net61}
N 1820 940 1820 990 {
lab=#net60}
N 1940 990 1940 1220 {
lab=GND}
N 1890 1020 1890 1140 {
lab=#net62}
N 1940 660 2070 660 {lab=VDD}
N 1890 660 1890 740 {lab=VDD}
N 2070 660 2070 890 {lab=VDD}
N 1850 740 1850 800 {lab=#net11}
N 1850 1100 1850 1170 {lab=VCtrl}
N 1630 1220 1890 1220 {lab=GND}
N 1890 770 1890 860 {lab=#net63}
N 1890 1170 1890 1220 {lab=GND}
N 1940 660 1940 890 {lab=VDD}
N 1890 660 1940 660 {lab=VDD}
N 1890 1220 1940 1220 {lab=GND}
N 1630 940 1820 940 {lab=#net60}
N 1820 890 1820 940 {
lab=#net60}
N 2070 940 2070 960 {
lab=#net64}
N 2070 990 2070 1220 {lab=GND}
N 1940 1220 2070 1220 {lab=GND}
N 2160 990 2190 990 {
lab=#net64}
N 2160 890 2190 890 {
lab=#net64}
N 2160 940 2160 990 {
lab=#net64}
N 2160 890 2160 940 {
lab=#net64}
N 2230 660 2230 890 {lab=VDD}
N 2230 940 2230 960 {
lab=#net65}
N 2230 990 2230 1220 {lab=GND}
N 2070 940 2160 940 {lab=#net64}
N 2070 920 2070 940 {
lab=#net64}
N 2070 1220 2230 1220 {lab=GND}
N 2070 660 2230 660 {lab=VDD}
N 2600 990 2630 990 {
lab=#net66}
N 2600 890 2630 890 {
lab=#net66}
N 2600 940 2600 990 {
lab=#net66}
N 2490 990 2540 990 {
lab=GND}
N 2490 890 2540 890 {
lab=VDD}
N 2490 940 2490 960 {
lab=#net66}
N 2420 990 2450 990 {
lab=#net65}
N 2420 890 2450 890 {
lab=#net65}
N 2490 920 2490 940 {
lab=#net66}
N 2490 940 2600 940 {
lab=#net66}
N 2600 890 2600 940 {
lab=#net66}
N 2420 940 2420 990 {
lab=#net65}
N 2540 990 2540 1220 {
lab=GND}
N 2490 1020 2490 1140 {
lab=#net67}
N 2540 660 2670 660 {lab=VDD}
N 2490 660 2490 740 {lab=VDD}
N 2670 660 2670 890 {lab=VDD}
N 2450 740 2450 800 {lab=#net11}
N 2450 1100 2450 1170 {lab=VCtrl}
N 2230 1220 2490 1220 {lab=GND}
N 2490 770 2490 860 {lab=#net68}
N 2490 1170 2490 1220 {lab=GND}
N 2540 660 2540 890 {lab=VDD}
N 2490 660 2540 660 {lab=VDD}
N 2490 1220 2540 1220 {lab=GND}
N 2230 940 2420 940 {lab=#net65}
N 2420 890 2420 940 {
lab=#net65}
N 2670 940 2670 960 {
lab=#net69}
N 2670 990 2670 1220 {lab=GND}
N 2540 1220 2670 1220 {lab=GND}
N 2760 990 2790 990 {
lab=#net69}
N 2760 890 2790 890 {
lab=#net69}
N 2760 940 2760 990 {
lab=#net69}
N 2760 890 2760 940 {
lab=#net69}
N 2830 660 2830 890 {lab=VDD}
N 2830 940 2830 960 {
lab=#net70}
N 2830 990 2830 1220 {lab=GND}
N 2670 940 2760 940 {lab=#net69}
N 2670 920 2670 940 {
lab=#net69}
N 2230 920 2230 940 {
lab=#net65}
N 1850 800 2450 800 {lab=#net11}
N 2230 660 2490 660 {lab=VDD}
N 1630 920 1630 940 {
lab=#net60}
N 1250 800 1850 800 {lab=#net11}
N 1250 1100 1850 1100 {lab=VCtrl}
N 1630 660 1890 660 {lab=VDD}
N 2670 1220 2830 1220 {lab=GND}
N 430 920 430 940 {
lab=#net30}
N 50 800 650 800 {lab=#net11}
N 430 660 690 660 {lab=VDD}
N 430 1220 690 1220 {lab=GND}
N 50 1100 650 1100 {lab=VCtrl}
N 810 80 840 80 {
lab=#net71}
N 810 -20 840 -20 {
lab=#net71}
N 810 30 810 80 {
lab=#net71}
N 700 80 750 80 {
lab=GND}
N 700 -20 750 -20 {
lab=VDD}
N 700 30 700 50 {
lab=#net71}
N 630 80 660 80 {
lab=#net50}
N 630 -20 660 -20 {
lab=#net50}
N 700 10 700 30 {
lab=#net71}
N 700 30 810 30 {
lab=#net71}
N 810 -20 810 30 {
lab=#net71}
N 630 30 630 80 {
lab=#net50}
N 750 80 750 310 {
lab=GND}
N 700 110 700 230 {
lab=#net72}
N 750 -250 880 -250 {lab=VDD}
N 700 -250 700 -170 {lab=VDD}
N 880 -250 880 -20 {lab=VDD}
N 660 -170 660 -110 {lab=#net1}
N 660 190 660 260 {lab=VCtrl}
N 700 -140 700 -50 {lab=#net73}
N 700 260 700 310 {lab=GND}
N 750 -250 750 -20 {lab=VDD}
N 700 -250 750 -250 {lab=VDD}
N 700 310 750 310 {lab=GND}
N 60 190 660 190 {lab=VCtrl}
N 440 30 630 30 {lab=#net50}
N 630 -20 630 30 {
lab=#net50}
N 880 30 880 50 {
lab=#net74}
N 880 80 880 310 {lab=GND}
N 750 310 880 310 {lab=GND}
N 970 80 1000 80 {
lab=#net74}
N 970 -20 1000 -20 {
lab=#net74}
N 970 30 970 80 {
lab=#net74}
N 970 -20 970 30 {
lab=#net74}
N 1040 -250 1040 -20 {lab=VDD}
N 1040 30 1040 50 {
lab=#net75}
N 1040 80 1040 310 {lab=GND}
N 880 30 970 30 {lab=#net74}
N 880 10 880 30 {
lab=#net74}
N 880 310 1040 310 {lab=GND}
N 880 -250 1040 -250 {lab=VDD}
N 1410 80 1440 80 {
lab=#net76}
N 1410 -20 1440 -20 {
lab=#net76}
N 1410 30 1410 80 {
lab=#net76}
N 1300 80 1350 80 {
lab=GND}
N 1300 -20 1350 -20 {
lab=VDD}
N 1300 30 1300 50 {
lab=#net76}
N 1230 80 1260 80 {
lab=#net75}
N 1230 -20 1260 -20 {
lab=#net75}
N 1300 10 1300 30 {
lab=#net76}
N 1300 30 1410 30 {
lab=#net76}
N 1410 -20 1410 30 {
lab=#net76}
N 1230 30 1230 80 {
lab=#net75}
N 1350 80 1350 310 {
lab=GND}
N 1300 110 1300 230 {
lab=#net77}
N 1350 -250 1480 -250 {lab=VDD}
N 1300 -250 1300 -170 {lab=VDD}
N 1480 -250 1480 -20 {lab=VDD}
N 1260 -170 1260 -110 {lab=#net1}
N 1260 190 1260 260 {lab=VCtrl}
N 1040 310 1300 310 {lab=GND}
N 1300 -140 1300 -50 {lab=#net78}
N 1300 260 1300 310 {lab=GND}
N 1350 -250 1350 -20 {lab=VDD}
N 1300 -250 1350 -250 {lab=VDD}
N 1300 310 1350 310 {lab=GND}
N 1040 30 1230 30 {lab=#net75}
N 1230 -20 1230 30 {
lab=#net75}
N 1480 30 1480 50 {
lab=#net79}
N 1480 80 1480 310 {lab=GND}
N 1350 310 1480 310 {lab=GND}
N 1570 80 1600 80 {
lab=#net79}
N 1570 -20 1600 -20 {
lab=#net79}
N 1570 30 1570 80 {
lab=#net79}
N 1570 -20 1570 30 {
lab=#net79}
N 1640 -250 1640 -20 {lab=VDD}
N 1640 30 1640 50 {
lab=#net80}
N 1640 80 1640 310 {lab=GND}
N 1480 30 1570 30 {lab=#net79}
N 1480 10 1480 30 {
lab=#net79}
N 1480 310 1640 310 {lab=GND}
N 1480 -250 1640 -250 {lab=VDD}
N 1040 10 1040 30 {
lab=#net75}
N 660 -110 1260 -110 {lab=#net1}
N 660 190 1260 190 {lab=VCtrl}
N 1040 -250 1300 -250 {lab=VDD}
N 2010 80 2040 80 {
lab=#net81}
N 2010 -20 2040 -20 {
lab=#net81}
N 2010 30 2010 80 {
lab=#net81}
N 1900 80 1950 80 {
lab=GND}
N 1900 -20 1950 -20 {
lab=VDD}
N 1900 30 1900 50 {
lab=#net81}
N 1830 80 1860 80 {
lab=#net80}
N 1830 -20 1860 -20 {
lab=#net80}
N 1900 10 1900 30 {
lab=#net81}
N 1900 30 2010 30 {
lab=#net81}
N 2010 -20 2010 30 {
lab=#net81}
N 1830 30 1830 80 {
lab=#net80}
N 1950 80 1950 310 {
lab=GND}
N 1900 110 1900 230 {
lab=#net82}
N 1950 -250 2080 -250 {lab=VDD}
N 1900 -250 1900 -170 {lab=VDD}
N 2080 -250 2080 -20 {lab=VDD}
N 1860 -170 1860 -110 {lab=#net1}
N 1860 190 1860 260 {lab=VCtrl}
N 1640 310 1900 310 {lab=GND}
N 1900 -140 1900 -50 {lab=#net83}
N 1900 260 1900 310 {lab=GND}
N 1950 -250 1950 -20 {lab=VDD}
N 1900 -250 1950 -250 {lab=VDD}
N 1900 310 1950 310 {lab=GND}
N 1640 30 1830 30 {lab=#net80}
N 1830 -20 1830 30 {
lab=#net80}
N 2080 30 2080 50 {
lab=#net84}
N 2080 80 2080 310 {lab=GND}
N 1950 310 2080 310 {lab=GND}
N 2170 80 2200 80 {
lab=#net84}
N 2170 -20 2200 -20 {
lab=#net84}
N 2170 30 2170 80 {
lab=#net84}
N 2170 -20 2170 30 {
lab=#net84}
N 2240 -250 2240 -20 {lab=VDD}
N 2240 30 2240 50 {
lab=#net85}
N 2240 80 2240 310 {lab=GND}
N 2080 30 2170 30 {lab=#net84}
N 2080 10 2080 30 {
lab=#net84}
N 2080 310 2240 310 {lab=GND}
N 2080 -250 2240 -250 {lab=VDD}
N 2610 80 2640 80 {
lab=#net86}
N 2610 -20 2640 -20 {
lab=#net86}
N 2610 30 2610 80 {
lab=#net86}
N 2500 80 2550 80 {
lab=GND}
N 2500 -20 2550 -20 {
lab=VDD}
N 2500 30 2500 50 {
lab=#net86}
N 2430 80 2460 80 {
lab=#net85}
N 2430 -20 2460 -20 {
lab=#net85}
N 2500 10 2500 30 {
lab=#net86}
N 2500 30 2610 30 {
lab=#net86}
N 2610 -20 2610 30 {
lab=#net86}
N 2430 30 2430 80 {
lab=#net85}
N 2550 80 2550 310 {
lab=GND}
N 2500 110 2500 230 {
lab=#net87}
N 2550 -250 2680 -250 {lab=VDD}
N 2500 -250 2500 -170 {lab=VDD}
N 2680 -250 2680 -20 {lab=VDD}
N 2460 -170 2460 -110 {lab=#net1}
N 2460 190 2460 260 {lab=VCtrl}
N 2240 310 2500 310 {lab=GND}
N 2500 -140 2500 -50 {lab=#net88}
N 2500 260 2500 310 {lab=GND}
N 2550 -250 2550 -20 {lab=VDD}
N 2500 -250 2550 -250 {lab=VDD}
N 2500 310 2550 310 {lab=GND}
N 2240 30 2430 30 {lab=#net85}
N 2430 -20 2430 30 {
lab=#net85}
N 2680 30 2680 50 {
lab=#net89}
N 2680 80 2680 310 {lab=GND}
N 2550 310 2680 310 {lab=GND}
N 2770 80 2800 80 {
lab=#net89}
N 2770 -20 2800 -20 {
lab=#net89}
N 2770 30 2770 80 {
lab=#net89}
N 2770 -20 2770 30 {
lab=#net89}
N 2840 -250 2840 -20 {lab=VDD}
N 2840 30 2840 50 {
lab=#net90}
N 2840 80 2840 310 {lab=GND}
N 2680 30 2770 30 {lab=#net89}
N 2680 10 2680 30 {
lab=#net89}
N 2680 -250 2840 -250 {lab=VDD}
N 2240 10 2240 30 {
lab=#net85}
N 1860 -110 2460 -110 {lab=#net1}
N 2240 -250 2500 -250 {lab=VDD}
N 1640 10 1640 30 {
lab=#net80}
N 1260 -110 1860 -110 {lab=#net1}
N 1260 190 1860 190 {lab=VCtrl}
N 1640 -250 1900 -250 {lab=VDD}
N 440 10 440 30 {
lab=#net50}
N 60 -110 660 -110 {lab=#net1}
N 440 -250 700 -250 {lab=VDD}
N 440 310 700 310 {lab=GND}
N 3200 990 3230 990 {
lab=#net91}
N 3200 890 3230 890 {
lab=#net91}
N 3200 940 3200 990 {
lab=#net91}
N 3090 990 3140 990 {
lab=GND}
N 3090 890 3140 890 {
lab=VDD}
N 3090 940 3090 960 {
lab=#net91}
N 3020 990 3050 990 {
lab=#net70}
N 3020 890 3050 890 {
lab=#net70}
N 3090 920 3090 940 {
lab=#net91}
N 3090 940 3200 940 {
lab=#net91}
N 3200 890 3200 940 {
lab=#net91}
N 3020 940 3020 990 {
lab=#net70}
N 3140 990 3140 1220 {
lab=GND}
N 3090 1020 3090 1140 {
lab=#net92}
N 3140 660 3270 660 {lab=VDD}
N 3090 660 3090 740 {lab=VDD}
N 3270 660 3270 890 {lab=VDD}
N 3050 740 3050 800 {lab=#net11}
N 3050 1100 3050 1170 {lab=VCtrl}
N 3050 800 3650 800 {lab=#net11}
N 3090 770 3090 860 {lab=#net93}
N 3090 1170 3090 1220 {lab=GND}
N 3140 660 3140 890 {lab=VDD}
N 3090 660 3140 660 {lab=VDD}
N 3090 1220 3140 1220 {lab=GND}
N 2830 940 3020 940 {lab=#net70}
N 3020 890 3020 940 {
lab=#net70}
N 3270 940 3270 960 {
lab=#net94}
N 3270 990 3270 1220 {lab=GND}
N 3140 1220 3270 1220 {lab=GND}
N 3360 990 3390 990 {
lab=#net94}
N 3360 890 3390 890 {
lab=#net94}
N 3360 940 3360 990 {
lab=#net94}
N 3360 890 3360 940 {
lab=#net94}
N 3430 660 3430 890 {lab=VDD}
N 3430 940 3430 960 {
lab=#net95}
N 3430 990 3430 1220 {lab=GND}
N 3270 940 3360 940 {lab=#net94}
N 3270 920 3270 940 {
lab=#net94}
N 3270 1220 3430 1220 {lab=GND}
N 3270 660 3430 660 {lab=VDD}
N 3800 990 3830 990 {
lab=#net96}
N 3800 890 3830 890 {
lab=#net96}
N 3800 940 3800 990 {
lab=#net96}
N 3690 990 3740 990 {
lab=GND}
N 3690 890 3740 890 {
lab=VDD}
N 3690 940 3690 960 {
lab=#net96}
N 3620 990 3650 990 {
lab=#net95}
N 3620 890 3650 890 {
lab=#net95}
N 3690 920 3690 940 {
lab=#net96}
N 3690 940 3800 940 {
lab=#net96}
N 3800 890 3800 940 {
lab=#net96}
N 3620 940 3620 990 {
lab=#net95}
N 3740 990 3740 1220 {
lab=GND}
N 3690 1020 3690 1140 {
lab=#net97}
N 3740 660 3870 660 {lab=VDD}
N 3690 660 3690 740 {lab=VDD}
N 3870 660 3870 890 {lab=VDD}
N 3650 740 3650 800 {lab=#net11}
N 3650 1100 3650 1170 {lab=VCtrl}
N 3430 1220 3690 1220 {lab=GND}
N 3690 770 3690 860 {lab=#net98}
N 3690 1170 3690 1220 {lab=GND}
N 3740 660 3740 890 {lab=VDD}
N 3690 660 3740 660 {lab=VDD}
N 3690 1220 3740 1220 {lab=GND}
N 3430 940 3620 940 {lab=#net95}
N 3620 890 3620 940 {
lab=#net95}
N 3870 940 3870 960 {
lab=#net99}
N 3870 990 3870 1220 {lab=GND}
N 3740 1220 3870 1220 {lab=GND}
N 3960 990 3990 990 {
lab=#net99}
N 3960 890 3990 890 {
lab=#net99}
N 3960 940 3960 990 {
lab=#net99}
N 3960 890 3960 940 {
lab=#net99}
N 4030 660 4030 890 {lab=VDD}
N 4030 940 4030 960 {
lab=#net100}
N 4030 990 4030 1220 {lab=GND}
N 3870 940 3960 940 {lab=#net99}
N 3870 920 3870 940 {
lab=#net99}
N 3870 1220 4030 1220 {lab=GND}
N 3870 660 4030 660 {lab=VDD}
N 3430 920 3430 940 {
lab=#net95}
N 3050 1100 3650 1100 {lab=VCtrl}
N 3430 660 3690 660 {lab=VDD}
N 4400 990 4430 990 {
lab=#net101}
N 4400 890 4430 890 {
lab=#net101}
N 4400 940 4400 990 {
lab=#net101}
N 4290 990 4340 990 {
lab=GND}
N 4290 890 4340 890 {
lab=VDD}
N 4290 940 4290 960 {
lab=#net101}
N 4220 990 4250 990 {
lab=#net100}
N 4220 890 4250 890 {
lab=#net100}
N 4290 920 4290 940 {
lab=#net101}
N 4290 940 4400 940 {
lab=#net101}
N 4400 890 4400 940 {
lab=#net101}
N 4220 940 4220 990 {
lab=#net100}
N 4340 990 4340 1220 {
lab=GND}
N 4290 1020 4290 1140 {
lab=#net102}
N 4340 660 4470 660 {lab=VDD}
N 4290 660 4290 740 {lab=VDD}
N 4470 660 4470 890 {lab=VDD}
N 4250 740 4250 800 {lab=#net11}
N 4250 1100 4250 1170 {lab=VCtrl}
N 4030 1220 4290 1220 {lab=GND}
N 4290 770 4290 860 {lab=#net103}
N 4290 1170 4290 1220 {lab=GND}
N 4340 660 4340 890 {lab=VDD}
N 4290 660 4340 660 {lab=VDD}
N 4290 1220 4340 1220 {lab=GND}
N 4030 940 4220 940 {lab=#net100}
N 4220 890 4220 940 {
lab=#net100}
N 4470 940 4470 960 {
lab=#net104}
N 4470 990 4470 1220 {lab=GND}
N 4340 1220 4470 1220 {lab=GND}
N 4560 990 4590 990 {
lab=#net104}
N 4560 890 4590 890 {
lab=#net104}
N 4560 940 4560 990 {
lab=#net104}
N 4560 890 4560 940 {
lab=#net104}
N 4630 660 4630 890 {lab=VDD}
N 4630 940 4630 960 {
lab=#net105}
N 4630 990 4630 1220 {lab=GND}
N 4470 940 4560 940 {lab=#net104}
N 4470 920 4470 940 {
lab=#net104}
N 4470 1220 4630 1220 {lab=GND}
N 4470 660 4630 660 {lab=VDD}
N 5000 990 5030 990 {
lab=#net106}
N 5000 890 5030 890 {
lab=#net106}
N 5000 940 5000 990 {
lab=#net106}
N 4890 990 4940 990 {
lab=GND}
N 4890 890 4940 890 {
lab=VDD}
N 4890 940 4890 960 {
lab=#net106}
N 4820 990 4850 990 {
lab=#net105}
N 4820 890 4850 890 {
lab=#net105}
N 4890 920 4890 940 {
lab=#net106}
N 4890 940 5000 940 {
lab=#net106}
N 5000 890 5000 940 {
lab=#net106}
N 4820 940 4820 990 {
lab=#net105}
N 4940 990 4940 1220 {
lab=GND}
N 4890 1020 4890 1140 {
lab=#net107}
N 4940 660 5070 660 {lab=VDD}
N 4890 660 4890 740 {lab=VDD}
N 5070 660 5070 890 {lab=VDD}
N 4850 740 4850 800 {lab=#net11}
N 4850 1100 4850 1170 {lab=VCtrl}
N 4630 1220 4890 1220 {lab=GND}
N 4890 770 4890 860 {lab=#net108}
N 4890 1170 4890 1220 {lab=GND}
N 4940 660 4940 890 {lab=VDD}
N 4890 660 4940 660 {lab=VDD}
N 4890 1220 4940 1220 {lab=GND}
N 4630 940 4820 940 {lab=#net105}
N 4820 890 4820 940 {
lab=#net105}
N 5070 940 5070 960 {
lab=#net109}
N 5070 990 5070 1220 {lab=GND}
N 4940 1220 5070 1220 {lab=GND}
N 5160 990 5190 990 {
lab=#net109}
N 5160 890 5190 890 {
lab=#net109}
N 5160 940 5160 990 {
lab=#net109}
N 5160 890 5160 940 {
lab=#net109}
N 5230 660 5230 890 {lab=VDD}
N 5230 940 5230 960 {
lab=#net110}
N 5230 990 5230 1220 {lab=GND}
N 5070 940 5160 940 {lab=#net109}
N 5070 920 5070 940 {
lab=#net109}
N 5070 660 5230 660 {lab=VDD}
N 4630 920 4630 940 {
lab=#net105}
N 4250 800 4850 800 {lab=#net11}
N 4250 1100 4850 1100 {lab=VCtrl}
N 4630 660 4890 660 {lab=VDD}
N 4030 920 4030 940 {
lab=#net100}
N 3650 800 4250 800 {lab=#net11}
N 3650 1100 4250 1100 {lab=VCtrl}
N 4030 660 4290 660 {lab=VDD}
N 5070 1220 5230 1220 {lab=GND}
N 5600 990 5630 990 {
lab=#net111}
N 5600 890 5630 890 {
lab=#net111}
N 5600 940 5600 990 {
lab=#net111}
N 5490 990 5540 990 {
lab=GND}
N 5490 890 5540 890 {
lab=VDD}
N 5490 940 5490 960 {
lab=#net111}
N 5420 990 5450 990 {
lab=#net110}
N 5420 890 5450 890 {
lab=#net110}
N 5490 920 5490 940 {
lab=#net111}
N 5490 940 5600 940 {
lab=#net111}
N 5600 890 5600 940 {
lab=#net111}
N 5420 940 5420 990 {
lab=#net110}
N 5540 990 5540 1220 {
lab=GND}
N 5490 1020 5490 1140 {
lab=#net112}
N 5540 660 5670 660 {lab=VDD}
N 5490 660 5490 740 {lab=VDD}
N 5670 660 5670 890 {lab=VDD}
N 5450 740 5450 800 {lab=#net11}
N 5450 1100 5450 1170 {lab=VCtrl}
N 5490 770 5490 860 {lab=#net113}
N 5490 1170 5490 1220 {lab=GND}
N 5540 660 5540 890 {lab=VDD}
N 5490 660 5540 660 {lab=VDD}
N 5490 1220 5540 1220 {lab=GND}
N 5230 940 5420 940 {lab=#net110}
N 5420 890 5420 940 {
lab=#net110}
N 5670 940 5670 960 {
lab=#net114}
N 5670 990 5670 1220 {lab=GND}
N 5540 1220 5670 1220 {lab=GND}
N 5760 990 5790 990 {
lab=#net114}
N 5760 890 5790 890 {
lab=#net114}
N 5760 940 5760 990 {
lab=#net114}
N 5760 890 5760 940 {
lab=#net114}
N 5830 660 5830 890 {lab=VDD}
N 5830 940 5830 960 {
lab=#net115}
N 5830 990 5830 1220 {lab=GND}
N 5670 940 5760 940 {lab=#net114}
N 5670 920 5670 940 {
lab=#net114}
N 5670 1220 5830 1220 {lab=GND}
N 5670 660 5830 660 {lab=VDD}
N 6200 990 6230 990 {
lab=#net116}
N 6200 890 6230 890 {
lab=#net116}
N 6200 940 6200 990 {
lab=#net116}
N 6090 990 6140 990 {
lab=GND}
N 6090 890 6140 890 {
lab=VDD}
N 6090 940 6090 960 {
lab=#net116}
N 6020 990 6050 990 {
lab=#net115}
N 6020 890 6050 890 {
lab=#net115}
N 6090 920 6090 940 {
lab=#net116}
N 6090 940 6200 940 {
lab=#net116}
N 6200 890 6200 940 {
lab=#net116}
N 6020 940 6020 990 {
lab=#net115}
N 6140 990 6140 1220 {
lab=GND}
N 6090 1020 6090 1140 {
lab=#net117}
N 6140 660 6270 660 {lab=VDD}
N 6090 660 6090 740 {lab=VDD}
N 6270 660 6270 890 {lab=VDD}
N 6050 740 6050 800 {lab=#net11}
N 6050 1100 6050 1170 {lab=VCtrl}
N 5830 1220 6090 1220 {lab=GND}
N 6090 770 6090 860 {lab=#net118}
N 6090 1170 6090 1220 {lab=GND}
N 6140 660 6140 890 {lab=VDD}
N 6090 660 6140 660 {lab=VDD}
N 6090 1220 6140 1220 {lab=GND}
N 5830 940 6020 940 {lab=#net115}
N 6020 890 6020 940 {
lab=#net115}
N 6270 940 6270 960 {
lab=#net119}
N 6270 990 6270 1220 {lab=GND}
N 6140 1220 6270 1220 {lab=GND}
N 6360 990 6390 990 {
lab=#net119}
N 6360 890 6390 890 {
lab=#net119}
N 6360 940 6360 990 {
lab=#net119}
N 6360 890 6360 940 {
lab=#net119}
N 6430 660 6430 890 {lab=VDD}
N 6430 940 6430 960 {
lab=#net120}
N 6430 990 6430 1220 {lab=GND}
N 6270 940 6360 940 {lab=#net119}
N 6270 920 6270 940 {
lab=#net119}
N 6270 1220 6430 1220 {lab=GND}
N 6270 660 6430 660 {lab=VDD}
N 5830 920 5830 940 {
lab=#net115}
N 5450 800 6050 800 {lab=#net11}
N 5450 1100 6050 1100 {lab=VCtrl}
N 5830 660 6090 660 {lab=VDD}
N 6800 990 6830 990 {
lab=#net121}
N 6800 890 6830 890 {
lab=#net121}
N 6800 940 6800 990 {
lab=#net121}
N 6690 990 6740 990 {
lab=GND}
N 6690 890 6740 890 {
lab=VDD}
N 6690 940 6690 960 {
lab=#net121}
N 6620 990 6650 990 {
lab=#net120}
N 6620 890 6650 890 {
lab=#net120}
N 6690 920 6690 940 {
lab=#net121}
N 6690 940 6800 940 {
lab=#net121}
N 6800 890 6800 940 {
lab=#net121}
N 6620 940 6620 990 {
lab=#net120}
N 6740 990 6740 1220 {
lab=GND}
N 6690 1020 6690 1140 {
lab=#net122}
N 6740 660 6870 660 {lab=VDD}
N 6690 660 6690 740 {lab=VDD}
N 6870 660 6870 890 {lab=VDD}
N 6650 740 6650 800 {lab=#net11}
N 6650 1100 6650 1170 {lab=VCtrl}
N 6430 1220 6690 1220 {lab=GND}
N 6690 770 6690 860 {lab=#net123}
N 6690 1170 6690 1220 {lab=GND}
N 6740 660 6740 890 {lab=VDD}
N 6690 660 6740 660 {lab=VDD}
N 6690 1220 6740 1220 {lab=GND}
N 6430 940 6620 940 {lab=#net120}
N 6620 890 6620 940 {
lab=#net120}
N 6870 940 6870 960 {
lab=#net124}
N 6870 990 6870 1220 {lab=GND}
N 6740 1220 6870 1220 {lab=GND}
N 6960 990 6990 990 {
lab=#net124}
N 6960 890 6990 890 {
lab=#net124}
N 6960 940 6960 990 {
lab=#net124}
N 6960 890 6960 940 {
lab=#net124}
N 7030 660 7030 890 {lab=VDD}
N 7030 940 7030 960 {
lab=#net125}
N 7030 990 7030 1220 {lab=GND}
N 6870 940 6960 940 {lab=#net124}
N 6870 920 6870 940 {
lab=#net124}
N 6870 1220 7030 1220 {lab=GND}
N 6870 660 7030 660 {lab=VDD}
N 7400 990 7430 990 {
lab=#net126}
N 7400 890 7430 890 {
lab=#net126}
N 7400 940 7400 990 {
lab=#net126}
N 7290 990 7340 990 {
lab=GND}
N 7290 890 7340 890 {
lab=VDD}
N 7290 940 7290 960 {
lab=#net126}
N 7220 990 7250 990 {
lab=#net125}
N 7220 890 7250 890 {
lab=#net125}
N 7290 920 7290 940 {
lab=#net126}
N 7290 940 7400 940 {
lab=#net126}
N 7400 890 7400 940 {
lab=#net126}
N 7220 940 7220 990 {
lab=#net125}
N 7340 990 7340 1220 {
lab=GND}
N 7290 1020 7290 1140 {
lab=#net127}
N 7340 660 7470 660 {lab=VDD}
N 7290 660 7290 740 {lab=VDD}
N 7470 660 7470 890 {lab=VDD}
N 7250 740 7250 800 {lab=#net11}
N 7250 1100 7250 1170 {lab=VCtrl}
N 7030 1220 7290 1220 {lab=GND}
N 7290 770 7290 860 {lab=#net128}
N 7290 1170 7290 1220 {lab=GND}
N 7340 660 7340 890 {lab=VDD}
N 7290 660 7340 660 {lab=VDD}
N 7290 1220 7340 1220 {lab=GND}
N 7030 940 7220 940 {lab=#net125}
N 7220 890 7220 940 {
lab=#net125}
N 7470 940 7470 960 {
lab=#net129}
N 7470 990 7470 1220 {lab=GND}
N 7340 1220 7470 1220 {lab=GND}
N 7560 990 7590 990 {
lab=#net129}
N 7560 890 7590 890 {
lab=#net129}
N 7560 940 7560 990 {
lab=#net129}
N 7560 890 7560 940 {
lab=#net129}
N 7630 660 7630 890 {lab=VDD}
N 7630 940 7630 960 {
lab=#net130}
N 7630 990 7630 1220 {lab=GND}
N 7470 940 7560 940 {lab=#net129}
N 7470 920 7470 940 {
lab=#net129}
N 7030 920 7030 940 {
lab=#net125}
N 6650 800 7250 800 {lab=#net11}
N 6650 1100 7250 1100 {lab=VCtrl}
N 7030 660 7290 660 {lab=VDD}
N 6430 920 6430 940 {
lab=#net120}
N 6050 800 6650 800 {lab=#net11}
N 6050 1100 6650 1100 {lab=VCtrl}
N 6430 660 6690 660 {lab=VDD}
N 7470 1220 7630 1220 {lab=GND}
N 5230 920 5230 940 {
lab=#net110}
N 4850 800 5450 800 {lab=#net11}
N 5230 660 5490 660 {lab=VDD}
N 5230 1220 5490 1220 {lab=GND}
N 4850 1100 5450 1100 {lab=VCtrl}
N 2830 920 2830 940 {
lab=#net70}
N 2830 660 3090 660 {lab=VDD}
N 2670 660 2830 660 {lab=VDD}
N 2450 800 3050 800 {lab=#net11}
N 2450 1100 3050 1100 {lab=VCtrl}
N 1850 1100 2450 1100 {lab=VCtrl}
N 2830 1220 3090 1220 {lab=GND}
N 3210 80 3240 80 {
lab=#net131}
N 3210 -20 3240 -20 {
lab=#net131}
N 3210 30 3210 80 {
lab=#net131}
N 3100 80 3150 80 {
lab=GND}
N 3100 -20 3150 -20 {
lab=VDD}
N 3100 30 3100 50 {
lab=#net131}
N 3030 80 3060 80 {
lab=#net90}
N 3030 -20 3060 -20 {
lab=#net90}
N 3100 10 3100 30 {
lab=#net131}
N 3100 30 3210 30 {
lab=#net131}
N 3210 -20 3210 30 {
lab=#net131}
N 3030 30 3030 80 {
lab=#net90}
N 3150 80 3150 310 {
lab=GND}
N 3100 110 3100 230 {
lab=#net132}
N 3150 -250 3280 -250 {lab=VDD}
N 3100 -250 3100 -170 {lab=VDD}
N 3280 -250 3280 -20 {lab=VDD}
N 3060 -170 3060 -110 {lab=#net1}
N 3060 190 3060 260 {lab=VCtrl}
N 3100 -250 3150 -250 {lab=VDD}
N 3100 310 3150 310 {lab=GND}
N 3100 -140 3100 -50 {lab=#net133}
N 3100 260 3100 310 {lab=GND}
N 3150 -250 3150 -20 {lab=VDD}
N 2840 30 3030 30 {lab=#net90}
N 3030 -20 3030 30 {
lab=#net90}
N 3280 30 3280 50 {
lab=#net134}
N 3280 80 3280 310 {lab=GND}
N 3150 310 3280 310 {lab=GND}
N 3370 80 3400 80 {
lab=#net134}
N 3370 -20 3400 -20 {
lab=#net134}
N 3370 30 3370 80 {
lab=#net134}
N 3370 -20 3370 30 {
lab=#net134}
N 3440 -250 3440 -20 {lab=VDD}
N 3440 30 3440 50 {
lab=#net135}
N 3440 80 3440 310 {lab=GND}
N 3280 30 3370 30 {lab=#net134}
N 3280 10 3280 30 {
lab=#net134}
N 3280 310 3440 310 {lab=GND}
N 3280 -250 3440 -250 {lab=VDD}
N 3810 80 3840 80 {
lab=#net136}
N 3810 -20 3840 -20 {
lab=#net136}
N 3810 30 3810 80 {
lab=#net136}
N 3700 80 3750 80 {
lab=GND}
N 3700 -20 3750 -20 {
lab=VDD}
N 3700 30 3700 50 {
lab=#net136}
N 3630 80 3660 80 {
lab=#net135}
N 3630 -20 3660 -20 {
lab=#net135}
N 3700 10 3700 30 {
lab=#net136}
N 3700 30 3810 30 {
lab=#net136}
N 3810 -20 3810 30 {
lab=#net136}
N 3630 30 3630 80 {
lab=#net135}
N 3750 80 3750 310 {
lab=GND}
N 3700 110 3700 230 {
lab=#net137}
N 3750 -250 3880 -250 {lab=VDD}
N 3700 -250 3700 -170 {lab=VDD}
N 3880 -250 3880 -20 {lab=VDD}
N 3660 -170 3660 -110 {lab=#net1}
N 3660 190 3660 260 {lab=VCtrl}
N 3440 310 3700 310 {lab=GND}
N 3700 -140 3700 -50 {lab=#net138}
N 3700 260 3700 310 {lab=GND}
N 3750 -250 3750 -20 {lab=VDD}
N 3700 -250 3750 -250 {lab=VDD}
N 3700 310 3750 310 {lab=GND}
N 3440 30 3630 30 {lab=#net135}
N 3630 -20 3630 30 {
lab=#net135}
N 3880 30 3880 50 {
lab=#net139}
N 3880 80 3880 310 {lab=GND}
N 3750 310 3880 310 {lab=GND}
N 3970 80 4000 80 {
lab=#net139}
N 3970 -20 4000 -20 {
lab=#net139}
N 3970 30 3970 80 {
lab=#net139}
N 3970 -20 3970 30 {
lab=#net139}
N 4040 -250 4040 -20 {lab=VDD}
N 4040 30 4040 50 {
lab=#net140}
N 4040 80 4040 310 {lab=GND}
N 3880 30 3970 30 {lab=#net139}
N 3880 10 3880 30 {
lab=#net139}
N 3880 310 4040 310 {lab=GND}
N 3880 -250 4040 -250 {lab=VDD}
N 3440 10 3440 30 {
lab=#net135}
N 3060 -110 3660 -110 {lab=#net1}
N 3060 190 3660 190 {lab=VCtrl}
N 3440 -250 3700 -250 {lab=VDD}
N 4410 80 4440 80 {
lab=#net141}
N 4410 -20 4440 -20 {
lab=#net141}
N 4410 30 4410 80 {
lab=#net141}
N 4300 80 4350 80 {
lab=GND}
N 4300 -20 4350 -20 {
lab=VDD}
N 4300 30 4300 50 {
lab=#net141}
N 4230 80 4260 80 {
lab=#net140}
N 4230 -20 4260 -20 {
lab=#net140}
N 4300 10 4300 30 {
lab=#net141}
N 4300 30 4410 30 {
lab=#net141}
N 4410 -20 4410 30 {
lab=#net141}
N 4230 30 4230 80 {
lab=#net140}
N 4350 80 4350 310 {
lab=GND}
N 4300 110 4300 230 {
lab=#net142}
N 4350 -250 4480 -250 {lab=VDD}
N 4300 -250 4300 -170 {lab=VDD}
N 4480 -250 4480 -20 {lab=VDD}
N 4260 -170 4260 -110 {lab=#net1}
N 4260 190 4260 260 {lab=VCtrl}
N 4040 310 4300 310 {lab=GND}
N 4300 -140 4300 -50 {lab=#net143}
N 4300 260 4300 310 {lab=GND}
N 4350 -250 4350 -20 {lab=VDD}
N 4300 -250 4350 -250 {lab=VDD}
N 4300 310 4350 310 {lab=GND}
N 4040 30 4230 30 {lab=#net140}
N 4230 -20 4230 30 {
lab=#net140}
N 4480 30 4480 50 {
lab=#net144}
N 4480 80 4480 310 {lab=GND}
N 4350 310 4480 310 {lab=GND}
N 4570 80 4600 80 {
lab=#net144}
N 4570 -20 4600 -20 {
lab=#net144}
N 4570 30 4570 80 {
lab=#net144}
N 4570 -20 4570 30 {
lab=#net144}
N 4640 -250 4640 -20 {lab=VDD}
N 4640 30 4640 50 {
lab=#net145}
N 4640 80 4640 310 {lab=GND}
N 4480 30 4570 30 {lab=#net144}
N 4480 10 4480 30 {
lab=#net144}
N 4480 310 4640 310 {lab=GND}
N 4480 -250 4640 -250 {lab=VDD}
N 5010 80 5040 80 {
lab=#net146}
N 5010 -20 5040 -20 {
lab=#net146}
N 5010 30 5010 80 {
lab=#net146}
N 4900 80 4950 80 {
lab=GND}
N 4900 -20 4950 -20 {
lab=VDD}
N 4900 30 4900 50 {
lab=#net146}
N 4830 80 4860 80 {
lab=#net145}
N 4830 -20 4860 -20 {
lab=#net145}
N 4900 10 4900 30 {
lab=#net146}
N 4900 30 5010 30 {
lab=#net146}
N 5010 -20 5010 30 {
lab=#net146}
N 4830 30 4830 80 {
lab=#net145}
N 4950 80 4950 310 {
lab=GND}
N 4900 110 4900 230 {
lab=#net147}
N 4950 -250 5080 -250 {lab=VDD}
N 4900 -250 4900 -170 {lab=VDD}
N 5080 -250 5080 -20 {lab=VDD}
N 4860 -170 4860 -110 {lab=#net1}
N 4860 190 4860 260 {lab=VCtrl}
N 4640 310 4900 310 {lab=GND}
N 4900 -140 4900 -50 {lab=#net148}
N 4900 260 4900 310 {lab=GND}
N 4950 -250 4950 -20 {lab=VDD}
N 4900 -250 4950 -250 {lab=VDD}
N 4900 310 4950 310 {lab=GND}
N 4640 30 4830 30 {lab=#net145}
N 4830 -20 4830 30 {
lab=#net145}
N 5080 30 5080 50 {
lab=#net149}
N 5080 80 5080 310 {lab=GND}
N 4950 310 5080 310 {lab=GND}
N 5170 80 5200 80 {
lab=#net149}
N 5170 -20 5200 -20 {
lab=#net149}
N 5170 30 5170 80 {
lab=#net149}
N 5170 -20 5170 30 {
lab=#net149}
N 5240 -250 5240 -20 {lab=VDD}
N 5240 30 5240 50 {
lab=#net150}
N 5240 80 5240 310 {lab=GND}
N 5080 30 5170 30 {lab=#net149}
N 5080 10 5080 30 {
lab=#net149}
N 5080 -250 5240 -250 {lab=VDD}
N 4640 10 4640 30 {
lab=#net145}
N 4260 -110 4860 -110 {lab=#net1}
N 4260 190 4860 190 {lab=VCtrl}
N 4640 -250 4900 -250 {lab=VDD}
N 4040 10 4040 30 {
lab=#net140}
N 3660 -110 4260 -110 {lab=#net1}
N 3660 190 4260 190 {lab=VCtrl}
N 4040 -250 4300 -250 {lab=VDD}
N 5080 310 5240 310 {lab=GND}
N 5610 80 5640 80 {
lab=#net151}
N 5610 -20 5640 -20 {
lab=#net151}
N 5610 30 5610 80 {
lab=#net151}
N 5500 80 5550 80 {
lab=GND}
N 5500 -20 5550 -20 {
lab=VDD}
N 5500 30 5500 50 {
lab=#net151}
N 5430 80 5460 80 {
lab=#net150}
N 5430 -20 5460 -20 {
lab=#net150}
N 5500 10 5500 30 {
lab=#net151}
N 5500 30 5610 30 {
lab=#net151}
N 5610 -20 5610 30 {
lab=#net151}
N 5430 30 5430 80 {
lab=#net150}
N 5550 80 5550 310 {
lab=GND}
N 5500 110 5500 230 {
lab=#net152}
N 5550 -250 5680 -250 {lab=VDD}
N 5500 -250 5500 -170 {lab=VDD}
N 5680 -250 5680 -20 {lab=VDD}
N 5460 -170 5460 -110 {lab=#net1}
N 5460 190 5460 260 {lab=VCtrl}
N 5500 -140 5500 -50 {lab=#net153}
N 5500 260 5500 310 {lab=GND}
N 5550 -250 5550 -20 {lab=VDD}
N 5500 -250 5550 -250 {lab=VDD}
N 5500 310 5550 310 {lab=GND}
N 5240 30 5430 30 {lab=#net150}
N 5430 -20 5430 30 {
lab=#net150}
N 5680 30 5680 50 {
lab=#net154}
N 5680 80 5680 310 {lab=GND}
N 5550 310 5680 310 {lab=GND}
N 5770 80 5800 80 {
lab=#net154}
N 5770 -20 5800 -20 {
lab=#net154}
N 5770 30 5770 80 {
lab=#net154}
N 5770 -20 5770 30 {
lab=#net154}
N 5840 -250 5840 -20 {lab=VDD}
N 5840 30 5840 50 {
lab=#net155}
N 5840 80 5840 310 {lab=GND}
N 5680 30 5770 30 {lab=#net154}
N 5680 10 5680 30 {
lab=#net154}
N 5680 310 5840 310 {lab=GND}
N 5680 -250 5840 -250 {lab=VDD}
N 6210 80 6240 80 {
lab=#net156}
N 6210 -20 6240 -20 {
lab=#net156}
N 6210 30 6210 80 {
lab=#net156}
N 6100 80 6150 80 {
lab=GND}
N 6100 -20 6150 -20 {
lab=VDD}
N 6100 30 6100 50 {
lab=#net156}
N 6030 80 6060 80 {
lab=#net155}
N 6030 -20 6060 -20 {
lab=#net155}
N 6100 10 6100 30 {
lab=#net156}
N 6100 30 6210 30 {
lab=#net156}
N 6210 -20 6210 30 {
lab=#net156}
N 6030 30 6030 80 {
lab=#net155}
N 6150 80 6150 310 {
lab=GND}
N 6100 110 6100 230 {
lab=#net157}
N 6150 -250 6280 -250 {lab=VDD}
N 6100 -250 6100 -170 {lab=VDD}
N 6280 -250 6280 -20 {lab=VDD}
N 6060 -170 6060 -110 {lab=#net1}
N 6060 190 6060 260 {lab=VCtrl}
N 5840 310 6100 310 {lab=GND}
N 6100 -140 6100 -50 {lab=#net158}
N 6100 260 6100 310 {lab=GND}
N 6150 -250 6150 -20 {lab=VDD}
N 6100 -250 6150 -250 {lab=VDD}
N 6100 310 6150 310 {lab=GND}
N 5840 30 6030 30 {lab=#net155}
N 6030 -20 6030 30 {
lab=#net155}
N 6280 30 6280 50 {
lab=#net159}
N 6280 80 6280 310 {lab=GND}
N 6150 310 6280 310 {lab=GND}
N 6370 80 6400 80 {
lab=#net159}
N 6370 -20 6400 -20 {
lab=#net159}
N 6370 30 6370 80 {
lab=#net159}
N 6370 -20 6370 30 {
lab=#net159}
N 6440 -250 6440 -20 {lab=VDD}
N 6440 30 6440 50 {
lab=#net160}
N 6440 80 6440 310 {lab=GND}
N 6280 30 6370 30 {lab=#net159}
N 6280 10 6280 30 {
lab=#net159}
N 6280 310 6440 310 {lab=GND}
N 6280 -250 6440 -250 {lab=VDD}
N 5840 10 5840 30 {
lab=#net155}
N 5460 -110 6060 -110 {lab=#net1}
N 5460 190 6060 190 {lab=VCtrl}
N 5840 -250 6100 -250 {lab=VDD}
N 6810 80 6840 80 {
lab=#net161}
N 6810 -20 6840 -20 {
lab=#net161}
N 6810 30 6810 80 {
lab=#net161}
N 6700 80 6750 80 {
lab=GND}
N 6700 -20 6750 -20 {
lab=VDD}
N 6700 30 6700 50 {
lab=#net161}
N 6630 80 6660 80 {
lab=#net160}
N 6630 -20 6660 -20 {
lab=#net160}
N 6700 10 6700 30 {
lab=#net161}
N 6700 30 6810 30 {
lab=#net161}
N 6810 -20 6810 30 {
lab=#net161}
N 6630 30 6630 80 {
lab=#net160}
N 6750 80 6750 310 {
lab=GND}
N 6700 110 6700 230 {
lab=#net162}
N 6750 -250 6880 -250 {lab=VDD}
N 6700 -250 6700 -170 {lab=VDD}
N 6880 -250 6880 -20 {lab=VDD}
N 6660 -170 6660 -110 {lab=#net1}
N 6660 190 6660 260 {lab=VCtrl}
N 6440 310 6700 310 {lab=GND}
N 6700 -140 6700 -50 {lab=#net163}
N 6700 260 6700 310 {lab=GND}
N 6750 -250 6750 -20 {lab=VDD}
N 6700 -250 6750 -250 {lab=VDD}
N 6700 310 6750 310 {lab=GND}
N 6440 30 6630 30 {lab=#net160}
N 6630 -20 6630 30 {
lab=#net160}
N 6880 30 6880 50 {
lab=#net164}
N 6880 80 6880 310 {lab=GND}
N 6750 310 6880 310 {lab=GND}
N 6970 80 7000 80 {
lab=#net164}
N 6970 -20 7000 -20 {
lab=#net164}
N 6970 30 6970 80 {
lab=#net164}
N 6970 -20 6970 30 {
lab=#net164}
N 7040 -250 7040 -20 {lab=VDD}
N 7040 30 7040 50 {
lab=#net165}
N 7040 80 7040 310 {lab=GND}
N 6880 30 6970 30 {lab=#net164}
N 6880 10 6880 30 {
lab=#net164}
N 6880 310 7040 310 {lab=GND}
N 6880 -250 7040 -250 {lab=VDD}
N 7410 80 7440 80 {
lab=#net166}
N 7410 -20 7440 -20 {
lab=#net166}
N 7410 30 7410 80 {
lab=#net166}
N 7300 80 7350 80 {
lab=GND}
N 7300 -20 7350 -20 {
lab=VDD}
N 7300 30 7300 50 {
lab=#net166}
N 7230 80 7260 80 {
lab=#net165}
N 7230 -20 7260 -20 {
lab=#net165}
N 7300 10 7300 30 {
lab=#net166}
N 7300 30 7410 30 {
lab=#net166}
N 7410 -20 7410 30 {
lab=#net166}
N 7230 30 7230 80 {
lab=#net165}
N 7350 80 7350 310 {
lab=GND}
N 7300 110 7300 230 {
lab=#net167}
N 7350 -250 7480 -250 {lab=VDD}
N 7300 -250 7300 -170 {lab=VDD}
N 7480 -250 7480 -20 {lab=VDD}
N 7260 -170 7260 -110 {lab=#net1}
N 7260 190 7260 260 {lab=VCtrl}
N 7040 310 7300 310 {lab=GND}
N 7300 -140 7300 -50 {lab=#net168}
N 7300 260 7300 310 {lab=GND}
N 7350 -250 7350 -20 {lab=VDD}
N 7300 -250 7350 -250 {lab=VDD}
N 7300 310 7350 310 {lab=GND}
N 7040 30 7230 30 {lab=#net165}
N 7230 -20 7230 30 {
lab=#net165}
N 7480 30 7480 50 {
lab=#net169}
N 7480 80 7480 310 {lab=GND}
N 7350 310 7480 310 {lab=GND}
N 7570 80 7600 80 {
lab=#net169}
N 7570 -20 7600 -20 {
lab=#net169}
N 7570 30 7570 80 {
lab=#net169}
N 7570 -20 7570 30 {
lab=#net169}
N 7640 -250 7640 -20 {lab=VDD}
N 7640 30 7640 50 {
lab=#net170}
N 7640 80 7640 310 {lab=GND}
N 7480 30 7570 30 {lab=#net169}
N 7480 10 7480 30 {
lab=#net169}
N 7480 -250 7640 -250 {lab=VDD}
N 7040 10 7040 30 {
lab=#net165}
N 6660 -110 7260 -110 {lab=#net1}
N 6660 190 7260 190 {lab=VCtrl}
N 7040 -250 7300 -250 {lab=VDD}
N 6440 10 6440 30 {
lab=#net160}
N 6060 -110 6660 -110 {lab=#net1}
N 6060 190 6660 190 {lab=VCtrl}
N 6440 -250 6700 -250 {lab=VDD}
N 7480 310 7640 310 {lab=GND}
N 5240 10 5240 30 {
lab=#net150}
N 4860 -110 5460 -110 {lab=#net1}
N 5240 -250 5500 -250 {lab=VDD}
N 5240 310 5500 310 {lab=GND}
N 4860 190 5460 190 {lab=VCtrl}
N 2840 10 2840 30 {
lab=#net90}
N 2460 -110 3060 -110 {lab=#net1}
N 2840 -250 3100 -250 {lab=VDD}
N 2680 310 2840 310 {lab=GND}
N 2840 310 3100 310 {lab=GND}
N 2460 190 3060 190 {lab=VCtrl}
N 1860 190 2460 190 {lab=VCtrl}
N 8010 990 8040 990 {
lab=#net171}
N 8010 890 8040 890 {
lab=#net171}
N 8010 940 8010 990 {
lab=#net171}
N 7900 990 7950 990 {
lab=GND}
N 7900 890 7950 890 {
lab=VDD}
N 7900 940 7900 960 {
lab=#net171}
N 7830 990 7860 990 {
lab=#net130}
N 7830 890 7860 890 {
lab=#net130}
N 7900 920 7900 940 {
lab=#net171}
N 7900 940 8010 940 {
lab=#net171}
N 8010 890 8010 940 {
lab=#net171}
N 7830 940 7830 990 {
lab=#net130}
N 7950 990 7950 1220 {
lab=GND}
N 7900 1020 7900 1140 {
lab=#net172}
N 7950 660 8080 660 {lab=VDD}
N 7900 660 7900 740 {lab=VDD}
N 8080 660 8080 890 {lab=VDD}
N 7860 740 7860 800 {lab=#net11}
N 7860 1100 7860 1170 {lab=VCtrl}
N 7900 770 7900 860 {lab=#net173}
N 7900 1170 7900 1220 {lab=GND}
N 7950 660 7950 890 {lab=VDD}
N 7900 660 7950 660 {lab=VDD}
N 7900 1220 7950 1220 {lab=GND}
N 7830 890 7830 940 {
lab=#net130}
N 8080 940 8080 960 {
lab=#net174}
N 8080 990 8080 1220 {lab=GND}
N 7950 1220 8080 1220 {lab=GND}
N 8170 990 8200 990 {
lab=#net174}
N 8170 890 8200 890 {
lab=#net174}
N 8170 940 8170 990 {
lab=#net174}
N 8170 890 8170 940 {
lab=#net174}
N 8240 660 8240 890 {lab=VDD}
N 8240 940 8240 960 {
lab=#net175}
N 8240 990 8240 1220 {lab=GND}
N 8080 940 8170 940 {lab=#net174}
N 8080 920 8080 940 {
lab=#net174}
N 8080 1220 8240 1220 {lab=GND}
N 8080 660 8240 660 {lab=VDD}
N 8610 990 8640 990 {
lab=#net176}
N 8610 890 8640 890 {
lab=#net176}
N 8610 940 8610 990 {
lab=#net176}
N 8500 990 8550 990 {
lab=GND}
N 8500 890 8550 890 {
lab=VDD}
N 8500 940 8500 960 {
lab=#net176}
N 8430 990 8460 990 {
lab=#net175}
N 8430 890 8460 890 {
lab=#net175}
N 8500 920 8500 940 {
lab=#net176}
N 8500 940 8610 940 {
lab=#net176}
N 8610 890 8610 940 {
lab=#net176}
N 8430 940 8430 990 {
lab=#net175}
N 8550 990 8550 1220 {
lab=GND}
N 8500 1020 8500 1140 {
lab=#net177}
N 8550 660 8680 660 {lab=VDD}
N 8500 660 8500 740 {lab=VDD}
N 8680 660 8680 890 {lab=VDD}
N 8460 740 8460 800 {lab=#net11}
N 8460 1100 8460 1170 {lab=VCtrl}
N 8240 1220 8500 1220 {lab=GND}
N 8500 770 8500 860 {lab=#net178}
N 8500 1170 8500 1220 {lab=GND}
N 8550 660 8550 890 {lab=VDD}
N 8500 660 8550 660 {lab=VDD}
N 8500 1220 8550 1220 {lab=GND}
N 8240 940 8430 940 {lab=#net175}
N 8430 890 8430 940 {
lab=#net175}
N 8680 940 8680 960 {
lab=#net179}
N 8680 990 8680 1220 {lab=GND}
N 8550 1220 8680 1220 {lab=GND}
N 8770 990 8800 990 {
lab=#net179}
N 8770 890 8800 890 {
lab=#net179}
N 8770 940 8770 990 {
lab=#net179}
N 8770 890 8770 940 {
lab=#net179}
N 8840 660 8840 890 {lab=VDD}
N 8840 940 8840 960 {
lab=#net180}
N 8840 990 8840 1220 {lab=GND}
N 8680 940 8770 940 {lab=#net179}
N 8680 920 8680 940 {
lab=#net179}
N 8680 1220 8840 1220 {lab=GND}
N 8680 660 8840 660 {lab=VDD}
N 8240 920 8240 940 {
lab=#net175}
N 7860 800 8460 800 {lab=#net11}
N 7860 1100 8460 1100 {lab=VCtrl}
N 8240 660 8500 660 {lab=VDD}
N 9210 990 9240 990 {
lab=#net181}
N 9210 890 9240 890 {
lab=#net181}
N 9210 940 9210 990 {
lab=#net181}
N 9100 990 9150 990 {
lab=GND}
N 9100 890 9150 890 {
lab=VDD}
N 9100 940 9100 960 {
lab=#net181}
N 9030 990 9060 990 {
lab=#net180}
N 9030 890 9060 890 {
lab=#net180}
N 9100 920 9100 940 {
lab=#net181}
N 9100 940 9210 940 {
lab=#net181}
N 9210 890 9210 940 {
lab=#net181}
N 9030 940 9030 990 {
lab=#net180}
N 9150 990 9150 1220 {
lab=GND}
N 9100 1020 9100 1140 {
lab=#net182}
N 9150 660 9280 660 {lab=VDD}
N 9100 660 9100 740 {lab=VDD}
N 9280 660 9280 890 {lab=VDD}
N 9060 740 9060 800 {lab=#net11}
N 9060 1100 9060 1170 {lab=VCtrl}
N 8840 1220 9100 1220 {lab=GND}
N 9100 770 9100 860 {lab=#net183}
N 9100 1170 9100 1220 {lab=GND}
N 9150 660 9150 890 {lab=VDD}
N 9100 660 9150 660 {lab=VDD}
N 9100 1220 9150 1220 {lab=GND}
N 8840 940 9030 940 {lab=#net180}
N 9030 890 9030 940 {
lab=#net180}
N 9280 940 9280 960 {
lab=#net184}
N 9280 990 9280 1220 {lab=GND}
N 9150 1220 9280 1220 {lab=GND}
N 9370 990 9400 990 {
lab=#net184}
N 9370 890 9400 890 {
lab=#net184}
N 9370 940 9370 990 {
lab=#net184}
N 9370 890 9370 940 {
lab=#net184}
N 9440 660 9440 890 {lab=VDD}
N 9440 940 9440 960 {
lab=#net185}
N 9440 990 9440 1220 {lab=GND}
N 9280 940 9370 940 {lab=#net184}
N 9280 920 9280 940 {
lab=#net184}
N 9280 1220 9440 1220 {lab=GND}
N 9280 660 9440 660 {lab=VDD}
N 9810 990 9840 990 {
lab=#net186}
N 9810 890 9840 890 {
lab=#net186}
N 9810 940 9810 990 {
lab=#net186}
N 9700 990 9750 990 {
lab=GND}
N 9700 890 9750 890 {
lab=VDD}
N 9700 940 9700 960 {
lab=#net186}
N 9630 990 9660 990 {
lab=#net185}
N 9630 890 9660 890 {
lab=#net185}
N 9700 920 9700 940 {
lab=#net186}
N 9700 940 9810 940 {
lab=#net186}
N 9810 890 9810 940 {
lab=#net186}
N 9630 940 9630 990 {
lab=#net185}
N 9750 990 9750 1220 {
lab=GND}
N 9700 1020 9700 1140 {
lab=#net187}
N 9750 660 9880 660 {lab=VDD}
N 9700 660 9700 740 {lab=VDD}
N 9880 660 9880 890 {lab=VDD}
N 9660 740 9660 800 {lab=#net11}
N 9660 1100 9660 1170 {lab=VCtrl}
N 9440 1220 9700 1220 {lab=GND}
N 9700 770 9700 860 {lab=#net188}
N 9700 1170 9700 1220 {lab=GND}
N 9750 660 9750 890 {lab=VDD}
N 9700 660 9750 660 {lab=VDD}
N 9700 1220 9750 1220 {lab=GND}
N 9440 940 9630 940 {lab=#net185}
N 9630 890 9630 940 {
lab=#net185}
N 9880 940 9880 960 {
lab=#net189}
N 9880 990 9880 1220 {lab=GND}
N 9750 1220 9880 1220 {lab=GND}
N 9970 990 10000 990 {
lab=#net189}
N 9970 890 10000 890 {
lab=#net189}
N 9970 940 9970 990 {
lab=#net189}
N 9970 890 9970 940 {
lab=#net189}
N 10040 660 10040 890 {lab=VDD}
N 10040 940 10040 960 {
lab=#net190}
N 10040 990 10040 1220 {lab=GND}
N 9880 940 9970 940 {lab=#net189}
N 9880 920 9880 940 {
lab=#net189}
N 9880 660 10040 660 {lab=VDD}
N 9440 920 9440 940 {
lab=#net185}
N 9060 800 9660 800 {lab=#net11}
N 9060 1100 9660 1100 {lab=VCtrl}
N 9440 660 9700 660 {lab=VDD}
N 8840 920 8840 940 {
lab=#net180}
N 8460 800 9060 800 {lab=#net11}
N 8460 1100 9060 1100 {lab=VCtrl}
N 8840 660 9100 660 {lab=VDD}
N 9880 1220 10040 1220 {lab=GND}
N 8020 80 8050 80 {
lab=#net191}
N 8020 -20 8050 -20 {
lab=#net191}
N 8020 30 8020 80 {
lab=#net191}
N 7910 80 7960 80 {
lab=GND}
N 7910 -20 7960 -20 {
lab=VDD}
N 7910 30 7910 50 {
lab=#net191}
N 7840 80 7870 80 {
lab=#net170}
N 7840 -20 7870 -20 {
lab=#net170}
N 7910 10 7910 30 {
lab=#net191}
N 7910 30 8020 30 {
lab=#net191}
N 8020 -20 8020 30 {
lab=#net191}
N 7840 30 7840 80 {
lab=#net170}
N 7960 80 7960 310 {
lab=GND}
N 7910 110 7910 230 {
lab=#net192}
N 7960 -250 8090 -250 {lab=VDD}
N 7910 -250 7910 -170 {lab=VDD}
N 8090 -250 8090 -20 {lab=VDD}
N 7870 -170 7870 -110 {lab=#net1}
N 7870 190 7870 260 {lab=VCtrl}
N 7910 310 7960 310 {lab=GND}
N 7910 -140 7910 -50 {lab=#net193}
N 7910 260 7910 310 {lab=GND}
N 7960 -250 7960 -20 {lab=VDD}
N 7910 -250 7960 -250 {lab=VDD}
N 7840 -20 7840 30 {
lab=#net170}
N 8090 30 8090 50 {
lab=#net194}
N 8090 80 8090 310 {lab=GND}
N 7960 310 8090 310 {lab=GND}
N 8180 80 8210 80 {
lab=#net194}
N 8180 -20 8210 -20 {
lab=#net194}
N 8180 30 8180 80 {
lab=#net194}
N 8180 -20 8180 30 {
lab=#net194}
N 8250 -250 8250 -20 {lab=VDD}
N 8250 30 8250 50 {
lab=#net195}
N 8250 80 8250 310 {lab=GND}
N 8090 30 8180 30 {lab=#net194}
N 8090 10 8090 30 {
lab=#net194}
N 8090 310 8250 310 {lab=GND}
N 8090 -250 8250 -250 {lab=VDD}
N 8620 80 8650 80 {
lab=#net196}
N 8620 -20 8650 -20 {
lab=#net196}
N 8620 30 8620 80 {
lab=#net196}
N 8510 80 8560 80 {
lab=GND}
N 8510 -20 8560 -20 {
lab=VDD}
N 8510 30 8510 50 {
lab=#net196}
N 8440 80 8470 80 {
lab=#net195}
N 8440 -20 8470 -20 {
lab=#net195}
N 8510 10 8510 30 {
lab=#net196}
N 8510 30 8620 30 {
lab=#net196}
N 8620 -20 8620 30 {
lab=#net196}
N 8440 30 8440 80 {
lab=#net195}
N 8560 80 8560 310 {
lab=GND}
N 8510 110 8510 230 {
lab=#net197}
N 8560 -250 8690 -250 {lab=VDD}
N 8510 -250 8510 -170 {lab=VDD}
N 8690 -250 8690 -20 {lab=VDD}
N 8470 -170 8470 -110 {lab=#net1}
N 8470 190 8470 260 {lab=VCtrl}
N 8250 310 8510 310 {lab=GND}
N 8510 -140 8510 -50 {lab=#net198}
N 8510 260 8510 310 {lab=GND}
N 8560 -250 8560 -20 {lab=VDD}
N 8510 -250 8560 -250 {lab=VDD}
N 8510 310 8560 310 {lab=GND}
N 8250 30 8440 30 {lab=#net195}
N 8440 -20 8440 30 {
lab=#net195}
N 8690 30 8690 50 {
lab=#net199}
N 8690 80 8690 310 {lab=GND}
N 8560 310 8690 310 {lab=GND}
N 8780 80 8810 80 {
lab=#net199}
N 8780 -20 8810 -20 {
lab=#net199}
N 8780 30 8780 80 {
lab=#net199}
N 8780 -20 8780 30 {
lab=#net199}
N 8850 -250 8850 -20 {lab=VDD}
N 8850 30 8850 50 {
lab=#net200}
N 8850 80 8850 310 {lab=GND}
N 8690 30 8780 30 {lab=#net199}
N 8690 10 8690 30 {
lab=#net199}
N 8690 310 8850 310 {lab=GND}
N 8690 -250 8850 -250 {lab=VDD}
N 8250 10 8250 30 {
lab=#net195}
N 7870 -110 8470 -110 {lab=#net1}
N 7870 190 8470 190 {lab=VCtrl}
N 8250 -250 8510 -250 {lab=VDD}
N 9220 80 9250 80 {
lab=#net201}
N 9220 -20 9250 -20 {
lab=#net201}
N 9220 30 9220 80 {
lab=#net201}
N 9110 80 9160 80 {
lab=GND}
N 9110 -20 9160 -20 {
lab=VDD}
N 9110 30 9110 50 {
lab=#net201}
N 9040 80 9070 80 {
lab=#net200}
N 9040 -20 9070 -20 {
lab=#net200}
N 9110 10 9110 30 {
lab=#net201}
N 9110 30 9220 30 {
lab=#net201}
N 9220 -20 9220 30 {
lab=#net201}
N 9040 30 9040 80 {
lab=#net200}
N 9160 80 9160 310 {
lab=GND}
N 9110 110 9110 230 {
lab=#net202}
N 9160 -250 9290 -250 {lab=VDD}
N 9110 -250 9110 -170 {lab=VDD}
N 9290 -250 9290 -20 {lab=VDD}
N 9070 -170 9070 -110 {lab=#net1}
N 9070 190 9070 260 {lab=VCtrl}
N 8850 310 9110 310 {lab=GND}
N 9110 -140 9110 -50 {lab=#net203}
N 9110 260 9110 310 {lab=GND}
N 9160 -250 9160 -20 {lab=VDD}
N 9110 -250 9160 -250 {lab=VDD}
N 9110 310 9160 310 {lab=GND}
N 8850 30 9040 30 {lab=#net200}
N 9040 -20 9040 30 {
lab=#net200}
N 9290 30 9290 50 {
lab=#net204}
N 9290 80 9290 310 {lab=GND}
N 9160 310 9290 310 {lab=GND}
N 9380 80 9410 80 {
lab=#net204}
N 9380 -20 9410 -20 {
lab=#net204}
N 9380 30 9380 80 {
lab=#net204}
N 9380 -20 9380 30 {
lab=#net204}
N 9450 -250 9450 -20 {lab=VDD}
N 9450 30 9450 50 {
lab=#net205}
N 9450 80 9450 310 {lab=GND}
N 9290 30 9380 30 {lab=#net204}
N 9290 10 9290 30 {
lab=#net204}
N 9290 310 9450 310 {lab=GND}
N 9290 -250 9450 -250 {lab=VDD}
N 9820 80 9850 80 {
lab=#net206}
N 9820 -20 9850 -20 {
lab=#net206}
N 9820 30 9820 80 {
lab=#net206}
N 9710 80 9760 80 {
lab=GND}
N 9710 -20 9760 -20 {
lab=VDD}
N 9710 30 9710 50 {
lab=#net206}
N 9640 80 9670 80 {
lab=#net205}
N 9640 -20 9670 -20 {
lab=#net205}
N 9710 10 9710 30 {
lab=#net206}
N 9710 30 9820 30 {
lab=#net206}
N 9820 -20 9820 30 {
lab=#net206}
N 9640 30 9640 80 {
lab=#net205}
N 9760 80 9760 310 {
lab=GND}
N 9710 110 9710 230 {
lab=#net207}
N 9760 -250 9890 -250 {lab=VDD}
N 9710 -250 9710 -170 {lab=VDD}
N 9890 -250 9890 -20 {lab=VDD}
N 9670 -170 9670 -110 {lab=#net1}
N 9670 190 9670 260 {lab=VCtrl}
N 9450 310 9710 310 {lab=GND}
N 9710 -140 9710 -50 {lab=#net208}
N 9710 260 9710 310 {lab=GND}
N 9760 -250 9760 -20 {lab=VDD}
N 9710 -250 9760 -250 {lab=VDD}
N 9710 310 9760 310 {lab=GND}
N 9450 30 9640 30 {lab=#net205}
N 9640 -20 9640 30 {
lab=#net205}
N 9890 30 9890 50 {
lab=#net209}
N 9890 80 9890 310 {lab=GND}
N 9760 310 9890 310 {lab=GND}
N 9980 80 10010 80 {
lab=#net209}
N 9980 -20 10010 -20 {
lab=#net209}
N 9980 30 9980 80 {
lab=#net209}
N 9980 -20 9980 30 {
lab=#net209}
N 10050 -250 10050 -20 {lab=VDD}
N 10050 30 10050 50 {
lab=#net210}
N 10050 80 10050 310 {lab=GND}
N 9890 30 9980 30 {lab=#net209}
N 9890 10 9890 30 {
lab=#net209}
N 9890 -250 10050 -250 {lab=VDD}
N 9450 10 9450 30 {
lab=#net205}
N 9070 -110 9670 -110 {lab=#net1}
N 9070 190 9670 190 {lab=VCtrl}
N 9450 -250 9710 -250 {lab=VDD}
N 8850 10 8850 30 {
lab=#net200}
N 8470 -110 9070 -110 {lab=#net1}
N 8470 190 9070 190 {lab=VCtrl}
N 8850 -250 9110 -250 {lab=VDD}
N 9890 310 10050 310 {lab=GND}
N 7640 30 7840 30 {lab=#net170}
N 10410 990 10440 990 {
lab=#net211}
N 10410 890 10440 890 {
lab=#net211}
N 10410 940 10410 990 {
lab=#net211}
N 10300 990 10350 990 {
lab=GND}
N 10300 890 10350 890 {
lab=VDD}
N 10300 940 10300 960 {
lab=#net211}
N 10230 990 10260 990 {
lab=#net190}
N 10230 890 10260 890 {
lab=#net190}
N 10300 920 10300 940 {
lab=#net211}
N 10300 940 10410 940 {
lab=#net211}
N 10410 890 10410 940 {
lab=#net211}
N 10230 940 10230 990 {
lab=#net190}
N 10350 990 10350 1220 {
lab=GND}
N 10300 1020 10300 1140 {
lab=#net212}
N 10350 660 10480 660 {lab=VDD}
N 10300 660 10300 740 {lab=VDD}
N 10480 660 10480 890 {lab=VDD}
N 10260 740 10260 800 {lab=#net11}
N 10260 1100 10260 1170 {lab=VCtrl}
N 10300 770 10300 860 {lab=#net213}
N 10300 1170 10300 1220 {lab=GND}
N 10350 660 10350 890 {lab=VDD}
N 10300 660 10350 660 {lab=VDD}
N 10300 1220 10350 1220 {lab=GND}
N 10040 940 10230 940 {lab=#net190}
N 10230 890 10230 940 {
lab=#net190}
N 10480 940 10480 960 {
lab=#net214}
N 10480 990 10480 1220 {lab=GND}
N 10350 1220 10480 1220 {lab=GND}
N 10570 990 10600 990 {
lab=#net214}
N 10570 890 10600 890 {
lab=#net214}
N 10570 940 10570 990 {
lab=#net214}
N 10570 890 10570 940 {
lab=#net214}
N 10640 660 10640 890 {lab=VDD}
N 10640 940 10640 960 {
lab=#net215}
N 10640 990 10640 1220 {lab=GND}
N 10480 940 10570 940 {lab=#net214}
N 10480 920 10480 940 {
lab=#net214}
N 10480 1220 10640 1220 {lab=GND}
N 10480 660 10640 660 {lab=VDD}
N 11010 990 11040 990 {
lab=#net216}
N 11010 890 11040 890 {
lab=#net216}
N 11010 940 11010 990 {
lab=#net216}
N 10900 990 10950 990 {
lab=GND}
N 10900 890 10950 890 {
lab=VDD}
N 10900 940 10900 960 {
lab=#net216}
N 10830 990 10860 990 {
lab=#net215}
N 10830 890 10860 890 {
lab=#net215}
N 10900 920 10900 940 {
lab=#net216}
N 10900 940 11010 940 {
lab=#net216}
N 11010 890 11010 940 {
lab=#net216}
N 10830 940 10830 990 {
lab=#net215}
N 10950 990 10950 1220 {
lab=GND}
N 10900 1020 10900 1140 {
lab=#net217}
N 10950 660 11080 660 {lab=VDD}
N 10900 660 10900 740 {lab=VDD}
N 11080 660 11080 890 {lab=VDD}
N 10860 740 10860 800 {lab=#net11}
N 10860 1100 10860 1170 {lab=VCtrl}
N 10640 1220 10900 1220 {lab=GND}
N 10900 770 10900 860 {lab=#net218}
N 10900 1170 10900 1220 {lab=GND}
N 10950 660 10950 890 {lab=VDD}
N 10900 660 10950 660 {lab=VDD}
N 10900 1220 10950 1220 {lab=GND}
N 10640 940 10830 940 {lab=#net215}
N 10830 890 10830 940 {
lab=#net215}
N 11080 940 11080 960 {
lab=#net219}
N 11080 990 11080 1220 {lab=GND}
N 10950 1220 11080 1220 {lab=GND}
N 11170 990 11200 990 {
lab=#net219}
N 11170 890 11200 890 {
lab=#net219}
N 11170 940 11170 990 {
lab=#net219}
N 11170 890 11170 940 {
lab=#net219}
N 11240 660 11240 890 {lab=VDD}
N 11240 940 11240 960 {
lab=#net220}
N 11240 990 11240 1220 {lab=GND}
N 11080 940 11170 940 {lab=#net219}
N 11080 920 11080 940 {
lab=#net219}
N 11080 1220 11240 1220 {lab=GND}
N 11080 660 11240 660 {lab=VDD}
N 10640 920 10640 940 {
lab=#net215}
N 10260 800 10860 800 {lab=#net11}
N 10260 1100 10860 1100 {lab=VCtrl}
N 10640 660 10900 660 {lab=VDD}
N 11610 990 11640 990 {
lab=#net221}
N 11610 890 11640 890 {
lab=#net221}
N 11610 940 11610 990 {
lab=#net221}
N 11500 990 11550 990 {
lab=GND}
N 11500 890 11550 890 {
lab=VDD}
N 11500 940 11500 960 {
lab=#net221}
N 11430 990 11460 990 {
lab=#net220}
N 11430 890 11460 890 {
lab=#net220}
N 11500 920 11500 940 {
lab=#net221}
N 11500 940 11610 940 {
lab=#net221}
N 11610 890 11610 940 {
lab=#net221}
N 11430 940 11430 990 {
lab=#net220}
N 11550 990 11550 1220 {
lab=GND}
N 11500 1020 11500 1140 {
lab=#net222}
N 11550 660 11680 660 {lab=VDD}
N 11500 660 11500 740 {lab=VDD}
N 11680 660 11680 890 {lab=VDD}
N 11460 740 11460 800 {lab=#net11}
N 11460 1100 11460 1170 {lab=VCtrl}
N 11240 1220 11500 1220 {lab=GND}
N 11500 770 11500 860 {lab=#net223}
N 11500 1170 11500 1220 {lab=GND}
N 11550 660 11550 890 {lab=VDD}
N 11500 660 11550 660 {lab=VDD}
N 11500 1220 11550 1220 {lab=GND}
N 11240 940 11430 940 {lab=#net220}
N 11430 890 11430 940 {
lab=#net220}
N 11680 940 11680 960 {
lab=#net224}
N 11680 990 11680 1220 {lab=GND}
N 11550 1220 11680 1220 {lab=GND}
N 11770 990 11800 990 {
lab=#net224}
N 11770 890 11800 890 {
lab=#net224}
N 11770 940 11770 990 {
lab=#net224}
N 11770 890 11770 940 {
lab=#net224}
N 11840 660 11840 890 {lab=VDD}
N 11840 940 11840 960 {
lab=#net225}
N 11840 990 11840 1220 {lab=GND}
N 11680 940 11770 940 {lab=#net224}
N 11680 920 11680 940 {
lab=#net224}
N 11680 1220 11840 1220 {lab=GND}
N 11680 660 11840 660 {lab=VDD}
N 12210 990 12240 990 {
lab=#net226}
N 12210 890 12240 890 {
lab=#net226}
N 12210 940 12210 990 {
lab=#net226}
N 12100 990 12150 990 {
lab=GND}
N 12100 890 12150 890 {
lab=VDD}
N 12100 940 12100 960 {
lab=#net226}
N 12030 990 12060 990 {
lab=#net225}
N 12030 890 12060 890 {
lab=#net225}
N 12100 920 12100 940 {
lab=#net226}
N 12100 940 12210 940 {
lab=#net226}
N 12210 890 12210 940 {
lab=#net226}
N 12030 940 12030 990 {
lab=#net225}
N 12150 990 12150 1220 {
lab=GND}
N 12100 1020 12100 1140 {
lab=#net227}
N 12150 660 12280 660 {lab=VDD}
N 12100 660 12100 740 {lab=VDD}
N 12280 660 12280 890 {lab=VDD}
N 12060 740 12060 800 {lab=#net11}
N 12060 1100 12060 1170 {lab=VCtrl}
N 11840 1220 12100 1220 {lab=GND}
N 12100 770 12100 860 {lab=#net228}
N 12100 1170 12100 1220 {lab=GND}
N 12150 660 12150 890 {lab=VDD}
N 12100 660 12150 660 {lab=VDD}
N 12100 1220 12150 1220 {lab=GND}
N 11840 940 12030 940 {lab=#net225}
N 12030 890 12030 940 {
lab=#net225}
N 12280 940 12280 960 {
lab=#net229}
N 12280 990 12280 1220 {lab=GND}
N 12150 1220 12280 1220 {lab=GND}
N 12370 990 12400 990 {
lab=#net229}
N 12370 890 12400 890 {
lab=#net229}
N 12370 940 12370 990 {
lab=#net229}
N 12370 890 12370 940 {
lab=#net229}
N 12440 660 12440 890 {lab=VDD}
N 12440 940 12440 960 {
lab=#net230}
N 12440 990 12440 1220 {lab=GND}
N 12280 940 12370 940 {lab=#net229}
N 12280 920 12280 940 {
lab=#net229}
N 11840 920 11840 940 {
lab=#net225}
N 11460 800 12060 800 {lab=#net11}
N 11840 660 12100 660 {lab=VDD}
N 11240 920 11240 940 {
lab=#net220}
N 10860 800 11460 800 {lab=#net11}
N 10860 1100 11460 1100 {lab=VCtrl}
N 11240 660 11500 660 {lab=VDD}
N 12280 1220 12440 1220 {lab=GND}
N 10040 920 10040 940 {
lab=#net190}
N 9660 800 10260 800 {lab=#net11}
N 10040 660 10300 660 {lab=VDD}
N 10040 1220 10300 1220 {lab=GND}
N 9660 1100 10260 1100 {lab=VCtrl}
N 10420 80 10450 80 {
lab=#net231}
N 10420 -20 10450 -20 {
lab=#net231}
N 10420 30 10420 80 {
lab=#net231}
N 10310 80 10360 80 {
lab=GND}
N 10310 -20 10360 -20 {
lab=VDD}
N 10310 30 10310 50 {
lab=#net231}
N 10240 80 10270 80 {
lab=#net210}
N 10240 -20 10270 -20 {
lab=#net210}
N 10310 10 10310 30 {
lab=#net231}
N 10310 30 10420 30 {
lab=#net231}
N 10420 -20 10420 30 {
lab=#net231}
N 10240 30 10240 80 {
lab=#net210}
N 10360 80 10360 310 {
lab=GND}
N 10310 110 10310 230 {
lab=#net232}
N 10360 -250 10490 -250 {lab=VDD}
N 10310 -250 10310 -170 {lab=VDD}
N 10490 -250 10490 -20 {lab=VDD}
N 10270 -170 10270 -110 {lab=#net1}
N 10270 190 10270 260 {lab=VCtrl}
N 10310 -140 10310 -50 {lab=#net233}
N 10310 260 10310 310 {lab=GND}
N 10360 -250 10360 -20 {lab=VDD}
N 10310 -250 10360 -250 {lab=VDD}
N 10310 310 10360 310 {lab=GND}
N 9670 190 10270 190 {lab=VCtrl}
N 10050 30 10240 30 {lab=#net210}
N 10240 -20 10240 30 {
lab=#net210}
N 10490 30 10490 50 {
lab=#net234}
N 10490 80 10490 310 {lab=GND}
N 10360 310 10490 310 {lab=GND}
N 10580 80 10610 80 {
lab=#net234}
N 10580 -20 10610 -20 {
lab=#net234}
N 10580 30 10580 80 {
lab=#net234}
N 10580 -20 10580 30 {
lab=#net234}
N 10650 -250 10650 -20 {lab=VDD}
N 10650 30 10650 50 {
lab=#net235}
N 10650 80 10650 310 {lab=GND}
N 10490 30 10580 30 {lab=#net234}
N 10490 10 10490 30 {
lab=#net234}
N 10490 310 10650 310 {lab=GND}
N 10490 -250 10650 -250 {lab=VDD}
N 11020 80 11050 80 {
lab=#net236}
N 11020 -20 11050 -20 {
lab=#net236}
N 11020 30 11020 80 {
lab=#net236}
N 10910 80 10960 80 {
lab=GND}
N 10910 -20 10960 -20 {
lab=VDD}
N 10910 30 10910 50 {
lab=#net236}
N 10840 80 10870 80 {
lab=#net235}
N 10840 -20 10870 -20 {
lab=#net235}
N 10910 10 10910 30 {
lab=#net236}
N 10910 30 11020 30 {
lab=#net236}
N 11020 -20 11020 30 {
lab=#net236}
N 10840 30 10840 80 {
lab=#net235}
N 10960 80 10960 310 {
lab=GND}
N 10910 110 10910 230 {
lab=#net237}
N 10960 -250 11090 -250 {lab=VDD}
N 10910 -250 10910 -170 {lab=VDD}
N 11090 -250 11090 -20 {lab=VDD}
N 10870 -170 10870 -110 {lab=#net1}
N 10870 190 10870 260 {lab=VCtrl}
N 10650 310 10910 310 {lab=GND}
N 10910 -140 10910 -50 {lab=#net238}
N 10910 260 10910 310 {lab=GND}
N 10960 -250 10960 -20 {lab=VDD}
N 10910 -250 10960 -250 {lab=VDD}
N 10910 310 10960 310 {lab=GND}
N 10650 30 10840 30 {lab=#net235}
N 10840 -20 10840 30 {
lab=#net235}
N 11090 30 11090 50 {
lab=#net239}
N 11090 80 11090 310 {lab=GND}
N 10960 310 11090 310 {lab=GND}
N 11180 80 11210 80 {
lab=#net239}
N 11180 -20 11210 -20 {
lab=#net239}
N 11180 30 11180 80 {
lab=#net239}
N 11180 -20 11180 30 {
lab=#net239}
N 11250 -250 11250 -20 {lab=VDD}
N 11250 30 11250 50 {
lab=#net240}
N 11250 80 11250 310 {lab=GND}
N 11090 30 11180 30 {lab=#net239}
N 11090 10 11090 30 {
lab=#net239}
N 11090 310 11250 310 {lab=GND}
N 11090 -250 11250 -250 {lab=VDD}
N 10650 10 10650 30 {
lab=#net235}
N 10270 -110 10870 -110 {lab=#net1}
N 10270 190 10870 190 {lab=VCtrl}
N 10650 -250 10910 -250 {lab=VDD}
N 11620 80 11650 80 {
lab=#net241}
N 11620 -20 11650 -20 {
lab=#net241}
N 11620 30 11620 80 {
lab=#net241}
N 11510 80 11560 80 {
lab=GND}
N 11510 -20 11560 -20 {
lab=VDD}
N 11510 30 11510 50 {
lab=#net241}
N 11440 80 11470 80 {
lab=#net240}
N 11440 -20 11470 -20 {
lab=#net240}
N 11510 10 11510 30 {
lab=#net241}
N 11510 30 11620 30 {
lab=#net241}
N 11620 -20 11620 30 {
lab=#net241}
N 11440 30 11440 80 {
lab=#net240}
N 11560 80 11560 310 {
lab=GND}
N 11510 110 11510 230 {
lab=#net242}
N 11560 -250 11690 -250 {lab=VDD}
N 11510 -250 11510 -170 {lab=VDD}
N 11690 -250 11690 -20 {lab=VDD}
N 11470 -170 11470 -110 {lab=#net1}
N 11470 190 11470 260 {lab=VCtrl}
N 11250 310 11510 310 {lab=GND}
N 11510 -140 11510 -50 {lab=#net243}
N 11510 260 11510 310 {lab=GND}
N 11560 -250 11560 -20 {lab=VDD}
N 11510 -250 11560 -250 {lab=VDD}
N 11510 310 11560 310 {lab=GND}
N 11250 30 11440 30 {lab=#net240}
N 11440 -20 11440 30 {
lab=#net240}
N 11690 30 11690 50 {
lab=#net244}
N 11690 80 11690 310 {lab=GND}
N 11560 310 11690 310 {lab=GND}
N 11780 80 11810 80 {
lab=#net244}
N 11780 -20 11810 -20 {
lab=#net244}
N 11780 30 11780 80 {
lab=#net244}
N 11780 -20 11780 30 {
lab=#net244}
N 11850 -250 11850 -20 {lab=VDD}
N 11850 30 11850 50 {
lab=#net245}
N 11850 80 11850 310 {lab=GND}
N 11690 30 11780 30 {lab=#net244}
N 11690 10 11690 30 {
lab=#net244}
N 11690 310 11850 310 {lab=GND}
N 11690 -250 11850 -250 {lab=VDD}
N 12220 80 12250 80 {
lab=#net246}
N 12220 -20 12250 -20 {
lab=#net246}
N 12220 30 12220 80 {
lab=#net246}
N 12110 80 12160 80 {
lab=GND}
N 12110 -20 12160 -20 {
lab=VDD}
N 12110 30 12110 50 {
lab=#net246}
N 12040 80 12070 80 {
lab=#net245}
N 12040 -20 12070 -20 {
lab=#net245}
N 12110 10 12110 30 {
lab=#net246}
N 12110 30 12220 30 {
lab=#net246}
N 12220 -20 12220 30 {
lab=#net246}
N 12040 30 12040 80 {
lab=#net245}
N 12160 80 12160 310 {
lab=GND}
N 12110 110 12110 230 {
lab=#net247}
N 12160 -250 12290 -250 {lab=VDD}
N 12110 -250 12110 -170 {lab=VDD}
N 12290 -250 12290 -20 {lab=VDD}
N 12070 -170 12070 -110 {lab=#net1}
N 12070 190 12070 260 {lab=VCtrl}
N 11850 310 12110 310 {lab=GND}
N 12110 -140 12110 -50 {lab=#net248}
N 12110 260 12110 310 {lab=GND}
N 12160 -250 12160 -20 {lab=VDD}
N 12110 -250 12160 -250 {lab=VDD}
N 12110 310 12160 310 {lab=GND}
N 11850 30 12040 30 {lab=#net245}
N 12040 -20 12040 30 {
lab=#net245}
N 12290 30 12290 50 {
lab=#net249}
N 12290 80 12290 310 {lab=GND}
N 12160 310 12290 310 {lab=GND}
N 12380 80 12410 80 {
lab=#net249}
N 12380 -20 12410 -20 {
lab=#net249}
N 12380 30 12380 80 {
lab=#net249}
N 12380 -20 12380 30 {
lab=#net249}
N 12450 -250 12450 -20 {lab=VDD}
N 12450 30 12450 50 {
lab=#net250}
N 12450 80 12450 310 {lab=GND}
N 12290 30 12380 30 {lab=#net249}
N 12290 10 12290 30 {
lab=#net249}
N 12290 -250 12450 -250 {lab=VDD}
N 11850 10 11850 30 {
lab=#net245}
N 11470 -110 12070 -110 {lab=#net1}
N 11850 -250 12110 -250 {lab=VDD}
N 11250 10 11250 30 {
lab=#net240}
N 10870 -110 11470 -110 {lab=#net1}
N 10870 190 11470 190 {lab=VCtrl}
N 11250 -250 11510 -250 {lab=VDD}
N 10050 10 10050 30 {
lab=#net210}
N 9670 -110 10270 -110 {lab=#net1}
N 10050 -250 10310 -250 {lab=VDD}
N 10050 310 10310 310 {lab=GND}
N 12810 990 12840 990 {
lab=#net251}
N 12810 890 12840 890 {
lab=#net251}
N 12810 940 12810 990 {
lab=#net251}
N 12700 990 12750 990 {
lab=GND}
N 12700 890 12750 890 {
lab=VDD}
N 12700 940 12700 960 {
lab=#net251}
N 12630 990 12660 990 {
lab=#net230}
N 12630 890 12660 890 {
lab=#net230}
N 12700 920 12700 940 {
lab=#net251}
N 12700 940 12810 940 {
lab=#net251}
N 12810 890 12810 940 {
lab=#net251}
N 12630 940 12630 990 {
lab=#net230}
N 12750 990 12750 1220 {
lab=GND}
N 12700 1020 12700 1140 {
lab=#net252}
N 12750 660 12880 660 {lab=VDD}
N 12700 660 12700 740 {lab=VDD}
N 12880 660 12880 890 {lab=VDD}
N 12660 740 12660 800 {lab=#net11}
N 12660 1100 12660 1170 {lab=VCtrl}
N 12660 800 13260 800 {lab=#net11}
N 12700 770 12700 860 {lab=#net253}
N 12700 1170 12700 1220 {lab=GND}
N 12750 660 12750 890 {lab=VDD}
N 12700 660 12750 660 {lab=VDD}
N 12700 1220 12750 1220 {lab=GND}
N 12440 940 12630 940 {lab=#net230}
N 12630 890 12630 940 {
lab=#net230}
N 12880 940 12880 960 {
lab=#net254}
N 12880 990 12880 1220 {lab=GND}
N 12750 1220 12880 1220 {lab=GND}
N 12970 990 13000 990 {
lab=#net254}
N 12970 890 13000 890 {
lab=#net254}
N 12970 940 12970 990 {
lab=#net254}
N 12970 890 12970 940 {
lab=#net254}
N 13040 660 13040 890 {lab=VDD}
N 13040 940 13040 960 {
lab=#net255}
N 13040 990 13040 1220 {lab=GND}
N 12880 940 12970 940 {lab=#net254}
N 12880 920 12880 940 {
lab=#net254}
N 12880 1220 13040 1220 {lab=GND}
N 12880 660 13040 660 {lab=VDD}
N 13410 990 13440 990 {
lab=#net256}
N 13410 890 13440 890 {
lab=#net256}
N 13410 940 13410 990 {
lab=#net256}
N 13300 990 13350 990 {
lab=GND}
N 13300 890 13350 890 {
lab=VDD}
N 13300 940 13300 960 {
lab=#net256}
N 13230 990 13260 990 {
lab=#net255}
N 13230 890 13260 890 {
lab=#net255}
N 13300 920 13300 940 {
lab=#net256}
N 13300 940 13410 940 {
lab=#net256}
N 13410 890 13410 940 {
lab=#net256}
N 13230 940 13230 990 {
lab=#net255}
N 13350 990 13350 1220 {
lab=GND}
N 13300 1020 13300 1140 {
lab=#net257}
N 13350 660 13480 660 {lab=VDD}
N 13300 660 13300 740 {lab=VDD}
N 13480 660 13480 890 {lab=VDD}
N 13260 740 13260 800 {lab=#net11}
N 13260 1100 13260 1170 {lab=VCtrl}
N 13040 1220 13300 1220 {lab=GND}
N 13300 770 13300 860 {lab=#net258}
N 13300 1170 13300 1220 {lab=GND}
N 13350 660 13350 890 {lab=VDD}
N 13300 660 13350 660 {lab=VDD}
N 13300 1220 13350 1220 {lab=GND}
N 13040 940 13230 940 {lab=#net255}
N 13230 890 13230 940 {
lab=#net255}
N 13480 940 13480 960 {
lab=#net259}
N 13480 990 13480 1220 {lab=GND}
N 13350 1220 13480 1220 {lab=GND}
N 13570 990 13600 990 {
lab=#net259}
N 13570 890 13600 890 {
lab=#net259}
N 13570 940 13570 990 {
lab=#net259}
N 13570 890 13570 940 {
lab=#net259}
N 13640 660 13640 890 {lab=VDD}
N 13640 940 13640 960 {
lab=#net260}
N 13640 990 13640 1220 {lab=GND}
N 13480 940 13570 940 {lab=#net259}
N 13480 920 13480 940 {
lab=#net259}
N 13480 1220 13640 1220 {lab=GND}
N 13480 660 13640 660 {lab=VDD}
N 13040 920 13040 940 {
lab=#net255}
N 12660 1100 13260 1100 {lab=VCtrl}
N 13040 660 13300 660 {lab=VDD}
N 14010 990 14040 990 {
lab=#net261}
N 14010 890 14040 890 {
lab=#net261}
N 14010 940 14010 990 {
lab=#net261}
N 13900 990 13950 990 {
lab=GND}
N 13900 890 13950 890 {
lab=VDD}
N 13900 940 13900 960 {
lab=#net261}
N 13830 990 13860 990 {
lab=#net260}
N 13830 890 13860 890 {
lab=#net260}
N 13900 920 13900 940 {
lab=#net261}
N 13900 940 14010 940 {
lab=#net261}
N 14010 890 14010 940 {
lab=#net261}
N 13830 940 13830 990 {
lab=#net260}
N 13950 990 13950 1220 {
lab=GND}
N 13900 1020 13900 1140 {
lab=#net262}
N 13950 660 14080 660 {lab=VDD}
N 13900 660 13900 740 {lab=VDD}
N 14080 660 14080 890 {lab=VDD}
N 13860 740 13860 800 {lab=#net11}
N 13860 1100 13860 1170 {lab=VCtrl}
N 13640 1220 13900 1220 {lab=GND}
N 13900 770 13900 860 {lab=#net263}
N 13900 1170 13900 1220 {lab=GND}
N 13950 660 13950 890 {lab=VDD}
N 13900 660 13950 660 {lab=VDD}
N 13900 1220 13950 1220 {lab=GND}
N 13640 940 13830 940 {lab=#net260}
N 13830 890 13830 940 {
lab=#net260}
N 14080 940 14080 960 {
lab=#net264}
N 14080 990 14080 1220 {lab=GND}
N 13950 1220 14080 1220 {lab=GND}
N 14170 990 14200 990 {
lab=#net264}
N 14170 890 14200 890 {
lab=#net264}
N 14170 940 14170 990 {
lab=#net264}
N 14170 890 14170 940 {
lab=#net264}
N 14240 660 14240 890 {lab=VDD}
N 14240 940 14240 960 {
lab=#net265}
N 14240 990 14240 1220 {lab=GND}
N 14080 940 14170 940 {lab=#net264}
N 14080 920 14080 940 {
lab=#net264}
N 14080 1220 14240 1220 {lab=GND}
N 14080 660 14240 660 {lab=VDD}
N 14610 990 14640 990 {
lab=#net266}
N 14610 890 14640 890 {
lab=#net266}
N 14610 940 14610 990 {
lab=#net266}
N 14500 990 14550 990 {
lab=GND}
N 14500 890 14550 890 {
lab=VDD}
N 14500 940 14500 960 {
lab=#net266}
N 14430 990 14460 990 {
lab=#net265}
N 14430 890 14460 890 {
lab=#net265}
N 14500 920 14500 940 {
lab=#net266}
N 14500 940 14610 940 {
lab=#net266}
N 14610 890 14610 940 {
lab=#net266}
N 14430 940 14430 990 {
lab=#net265}
N 14550 990 14550 1220 {
lab=GND}
N 14500 1020 14500 1140 {
lab=#net267}
N 14550 660 14680 660 {lab=VDD}
N 14500 660 14500 740 {lab=VDD}
N 14680 660 14680 890 {lab=VDD}
N 14460 740 14460 800 {lab=#net11}
N 14460 1100 14460 1170 {lab=VCtrl}
N 14240 1220 14500 1220 {lab=GND}
N 14500 770 14500 860 {lab=#net268}
N 14500 1170 14500 1220 {lab=GND}
N 14550 660 14550 890 {lab=VDD}
N 14500 660 14550 660 {lab=VDD}
N 14500 1220 14550 1220 {lab=GND}
N 14240 940 14430 940 {lab=#net265}
N 14430 890 14430 940 {
lab=#net265}
N 14680 940 14680 960 {
lab=#net269}
N 14680 990 14680 1220 {lab=GND}
N 14550 1220 14680 1220 {lab=GND}
N 14770 990 14800 990 {
lab=#net269}
N 14770 890 14800 890 {
lab=#net269}
N 14770 940 14770 990 {
lab=#net269}
N 14770 890 14770 940 {
lab=#net269}
N 14840 660 14840 890 {lab=VDD}
N 14840 940 14840 960 {
lab=#net270}
N 14840 990 14840 1220 {lab=GND}
N 14680 940 14770 940 {lab=#net269}
N 14680 920 14680 940 {
lab=#net269}
N 14680 660 14840 660 {lab=VDD}
N 14240 920 14240 940 {
lab=#net265}
N 13860 800 14460 800 {lab=#net11}
N 13860 1100 14460 1100 {lab=VCtrl}
N 14240 660 14500 660 {lab=VDD}
N 13640 920 13640 940 {
lab=#net260}
N 13260 800 13860 800 {lab=#net11}
N 13260 1100 13860 1100 {lab=VCtrl}
N 13640 660 13900 660 {lab=VDD}
N 14680 1220 14840 1220 {lab=GND}
N 15210 990 15240 990 {
lab=#net271}
N 15210 890 15240 890 {
lab=#net271}
N 15210 940 15210 990 {
lab=#net271}
N 15100 990 15150 990 {
lab=GND}
N 15100 890 15150 890 {
lab=VDD}
N 15100 940 15100 960 {
lab=#net271}
N 15030 990 15060 990 {
lab=#net270}
N 15030 890 15060 890 {
lab=#net270}
N 15100 920 15100 940 {
lab=#net271}
N 15100 940 15210 940 {
lab=#net271}
N 15210 890 15210 940 {
lab=#net271}
N 15030 940 15030 990 {
lab=#net270}
N 15150 990 15150 1220 {
lab=GND}
N 15100 1020 15100 1140 {
lab=#net272}
N 15150 660 15280 660 {lab=VDD}
N 15100 660 15100 740 {lab=VDD}
N 15280 660 15280 890 {lab=VDD}
N 15060 740 15060 800 {lab=#net11}
N 15060 1100 15060 1170 {lab=VCtrl}
N 15100 770 15100 860 {lab=#net273}
N 15100 1170 15100 1220 {lab=GND}
N 15150 660 15150 890 {lab=VDD}
N 15100 660 15150 660 {lab=VDD}
N 15100 1220 15150 1220 {lab=GND}
N 14840 940 15030 940 {lab=#net270}
N 15030 890 15030 940 {
lab=#net270}
N 15280 940 15280 960 {
lab=#net274}
N 15280 990 15280 1220 {lab=GND}
N 15150 1220 15280 1220 {lab=GND}
N 15370 990 15400 990 {
lab=#net274}
N 15370 890 15400 890 {
lab=#net274}
N 15370 940 15370 990 {
lab=#net274}
N 15370 890 15370 940 {
lab=#net274}
N 15440 660 15440 890 {lab=VDD}
N 15440 940 15440 960 {
lab=#net275}
N 15440 990 15440 1220 {lab=GND}
N 15280 940 15370 940 {lab=#net274}
N 15280 920 15280 940 {
lab=#net274}
N 15280 1220 15440 1220 {lab=GND}
N 15280 660 15440 660 {lab=VDD}
N 15810 990 15840 990 {
lab=#net276}
N 15810 890 15840 890 {
lab=#net276}
N 15810 940 15810 990 {
lab=#net276}
N 15700 990 15750 990 {
lab=GND}
N 15700 890 15750 890 {
lab=VDD}
N 15700 940 15700 960 {
lab=#net276}
N 15630 990 15660 990 {
lab=#net275}
N 15630 890 15660 890 {
lab=#net275}
N 15700 920 15700 940 {
lab=#net276}
N 15700 940 15810 940 {
lab=#net276}
N 15810 890 15810 940 {
lab=#net276}
N 15630 940 15630 990 {
lab=#net275}
N 15750 990 15750 1220 {
lab=GND}
N 15700 1020 15700 1140 {
lab=#net277}
N 15750 660 15880 660 {lab=VDD}
N 15700 660 15700 740 {lab=VDD}
N 15880 660 15880 890 {lab=VDD}
N 15660 740 15660 800 {lab=#net11}
N 15660 1100 15660 1170 {lab=VCtrl}
N 15440 1220 15700 1220 {lab=GND}
N 15700 770 15700 860 {lab=#net278}
N 15700 1170 15700 1220 {lab=GND}
N 15750 660 15750 890 {lab=VDD}
N 15700 660 15750 660 {lab=VDD}
N 15700 1220 15750 1220 {lab=GND}
N 15440 940 15630 940 {lab=#net275}
N 15630 890 15630 940 {
lab=#net275}
N 15880 940 15880 960 {
lab=#net279}
N 15880 990 15880 1220 {lab=GND}
N 15750 1220 15880 1220 {lab=GND}
N 15970 990 16000 990 {
lab=#net279}
N 15970 890 16000 890 {
lab=#net279}
N 15970 940 15970 990 {
lab=#net279}
N 15970 890 15970 940 {
lab=#net279}
N 16040 660 16040 890 {lab=VDD}
N 16040 940 16040 960 {
lab=#net280}
N 16040 990 16040 1220 {lab=GND}
N 15880 940 15970 940 {lab=#net279}
N 15880 920 15880 940 {
lab=#net279}
N 15880 1220 16040 1220 {lab=GND}
N 15880 660 16040 660 {lab=VDD}
N 15440 920 15440 940 {
lab=#net275}
N 15060 800 15660 800 {lab=#net11}
N 15060 1100 15660 1100 {lab=VCtrl}
N 15440 660 15700 660 {lab=VDD}
N 16410 990 16440 990 {
lab=#net281}
N 16410 890 16440 890 {
lab=#net281}
N 16410 940 16410 990 {
lab=#net281}
N 16300 990 16350 990 {
lab=GND}
N 16300 890 16350 890 {
lab=VDD}
N 16300 940 16300 960 {
lab=#net281}
N 16230 990 16260 990 {
lab=#net280}
N 16230 890 16260 890 {
lab=#net280}
N 16300 920 16300 940 {
lab=#net281}
N 16300 940 16410 940 {
lab=#net281}
N 16410 890 16410 940 {
lab=#net281}
N 16230 940 16230 990 {
lab=#net280}
N 16350 990 16350 1220 {
lab=GND}
N 16300 1020 16300 1140 {
lab=#net282}
N 16350 660 16480 660 {lab=VDD}
N 16300 660 16300 740 {lab=VDD}
N 16480 660 16480 890 {lab=VDD}
N 16260 740 16260 800 {lab=#net11}
N 16260 1100 16260 1170 {lab=VCtrl}
N 16040 1220 16300 1220 {lab=GND}
N 16300 770 16300 860 {lab=#net283}
N 16300 1170 16300 1220 {lab=GND}
N 16350 660 16350 890 {lab=VDD}
N 16300 660 16350 660 {lab=VDD}
N 16300 1220 16350 1220 {lab=GND}
N 16040 940 16230 940 {lab=#net280}
N 16230 890 16230 940 {
lab=#net280}
N 16480 940 16480 960 {
lab=#net284}
N 16480 990 16480 1220 {lab=GND}
N 16350 1220 16480 1220 {lab=GND}
N 16570 990 16600 990 {
lab=#net284}
N 16570 890 16600 890 {
lab=#net284}
N 16570 940 16570 990 {
lab=#net284}
N 16570 890 16570 940 {
lab=#net284}
N 16640 660 16640 890 {lab=VDD}
N 16640 940 16640 960 {
lab=#net285}
N 16640 990 16640 1220 {lab=GND}
N 16480 940 16570 940 {lab=#net284}
N 16480 920 16480 940 {
lab=#net284}
N 16480 1220 16640 1220 {lab=GND}
N 16480 660 16640 660 {lab=VDD}
N 17010 990 17040 990 {
lab=#net286}
N 17010 890 17040 890 {
lab=#net286}
N 17010 940 17010 990 {
lab=#net286}
N 16900 990 16950 990 {
lab=GND}
N 16900 890 16950 890 {
lab=VDD}
N 16900 940 16900 960 {
lab=#net286}
N 16830 990 16860 990 {
lab=#net285}
N 16830 890 16860 890 {
lab=#net285}
N 16900 920 16900 940 {
lab=#net286}
N 16900 940 17010 940 {
lab=#net286}
N 17010 890 17010 940 {
lab=#net286}
N 16830 940 16830 990 {
lab=#net285}
N 16950 990 16950 1220 {
lab=GND}
N 16900 1020 16900 1140 {
lab=#net287}
N 16950 660 17080 660 {lab=VDD}
N 16900 660 16900 740 {lab=VDD}
N 17080 660 17080 890 {lab=VDD}
N 16860 740 16860 800 {lab=#net11}
N 16860 1100 16860 1170 {lab=VCtrl}
N 16640 1220 16900 1220 {lab=GND}
N 16900 770 16900 860 {lab=#net288}
N 16900 1170 16900 1220 {lab=GND}
N 16950 660 16950 890 {lab=VDD}
N 16900 660 16950 660 {lab=VDD}
N 16900 1220 16950 1220 {lab=GND}
N 16640 940 16830 940 {lab=#net285}
N 16830 890 16830 940 {
lab=#net285}
N 17080 940 17080 960 {
lab=#net289}
N 17080 990 17080 1220 {lab=GND}
N 16950 1220 17080 1220 {lab=GND}
N 17170 990 17200 990 {
lab=#net289}
N 17170 890 17200 890 {
lab=#net289}
N 17170 940 17170 990 {
lab=#net289}
N 17170 890 17170 940 {
lab=#net289}
N 17240 660 17240 890 {lab=VDD}
N 17240 920 17240 960 {
lab=delaycheckout}
N 17240 990 17240 1220 {lab=GND}
N 17080 940 17170 940 {lab=#net289}
N 17080 920 17080 940 {
lab=#net289}
N 17080 660 17240 660 {lab=VDD}
N 16640 920 16640 940 {
lab=#net285}
N 16260 800 16860 800 {lab=#net11}
N 16260 1100 16860 1100 {lab=VCtrl}
N 16640 660 16900 660 {lab=VDD}
N 16040 920 16040 940 {
lab=#net280}
N 15660 800 16260 800 {lab=#net11}
N 15660 1100 16260 1100 {lab=VCtrl}
N 16040 660 16300 660 {lab=VDD}
N 17080 1220 17240 1220 {lab=GND}
N 14840 920 14840 940 {
lab=#net270}
N 14460 800 15060 800 {lab=#net11}
N 14840 660 15100 660 {lab=VDD}
N 14840 1220 15100 1220 {lab=GND}
N 14460 1100 15060 1100 {lab=VCtrl}
N 12440 920 12440 940 {
lab=#net230}
N 12440 660 12700 660 {lab=VDD}
N 12280 660 12440 660 {lab=VDD}
N 12060 800 12660 800 {lab=#net11}
N 12060 1100 12660 1100 {lab=VCtrl}
N 11460 1100 12060 1100 {lab=VCtrl}
N 12440 1220 12700 1220 {lab=GND}
N 12820 80 12850 80 {
lab=#net290}
N 12820 -20 12850 -20 {
lab=#net290}
N 12820 30 12820 80 {
lab=#net290}
N 12710 80 12760 80 {
lab=GND}
N 12710 -20 12760 -20 {
lab=VDD}
N 12710 30 12710 50 {
lab=#net290}
N 12640 80 12670 80 {
lab=#net250}
N 12640 -20 12670 -20 {
lab=#net250}
N 12710 10 12710 30 {
lab=#net290}
N 12710 30 12820 30 {
lab=#net290}
N 12820 -20 12820 30 {
lab=#net290}
N 12640 30 12640 80 {
lab=#net250}
N 12760 80 12760 310 {
lab=GND}
N 12710 110 12710 230 {
lab=#net291}
N 12760 -250 12890 -250 {lab=VDD}
N 12710 -250 12710 -170 {lab=VDD}
N 12890 -250 12890 -20 {lab=VDD}
N 12670 -170 12670 -110 {lab=#net1}
N 12670 190 12670 260 {lab=VCtrl}
N 12710 -250 12760 -250 {lab=VDD}
N 12710 310 12760 310 {lab=GND}
N 12710 -140 12710 -50 {lab=#net292}
N 12710 260 12710 310 {lab=GND}
N 12760 -250 12760 -20 {lab=VDD}
N 12450 30 12640 30 {lab=#net250}
N 12640 -20 12640 30 {
lab=#net250}
N 12890 30 12890 50 {
lab=#net293}
N 12890 80 12890 310 {lab=GND}
N 12760 310 12890 310 {lab=GND}
N 12980 80 13010 80 {
lab=#net293}
N 12980 -20 13010 -20 {
lab=#net293}
N 12980 30 12980 80 {
lab=#net293}
N 12980 -20 12980 30 {
lab=#net293}
N 13050 -250 13050 -20 {lab=VDD}
N 13050 30 13050 50 {
lab=#net294}
N 13050 80 13050 310 {lab=GND}
N 12890 30 12980 30 {lab=#net293}
N 12890 10 12890 30 {
lab=#net293}
N 12890 310 13050 310 {lab=GND}
N 12890 -250 13050 -250 {lab=VDD}
N 13420 80 13450 80 {
lab=#net295}
N 13420 -20 13450 -20 {
lab=#net295}
N 13420 30 13420 80 {
lab=#net295}
N 13310 80 13360 80 {
lab=GND}
N 13310 -20 13360 -20 {
lab=VDD}
N 13310 30 13310 50 {
lab=#net295}
N 13240 80 13270 80 {
lab=#net294}
N 13240 -20 13270 -20 {
lab=#net294}
N 13310 10 13310 30 {
lab=#net295}
N 13310 30 13420 30 {
lab=#net295}
N 13420 -20 13420 30 {
lab=#net295}
N 13240 30 13240 80 {
lab=#net294}
N 13360 80 13360 310 {
lab=GND}
N 13310 110 13310 230 {
lab=#net296}
N 13360 -250 13490 -250 {lab=VDD}
N 13310 -250 13310 -170 {lab=VDD}
N 13490 -250 13490 -20 {lab=VDD}
N 13270 -170 13270 -110 {lab=#net1}
N 13270 190 13270 260 {lab=VCtrl}
N 13050 310 13310 310 {lab=GND}
N 13310 -140 13310 -50 {lab=#net297}
N 13310 260 13310 310 {lab=GND}
N 13360 -250 13360 -20 {lab=VDD}
N 13310 -250 13360 -250 {lab=VDD}
N 13310 310 13360 310 {lab=GND}
N 13050 30 13240 30 {lab=#net294}
N 13240 -20 13240 30 {
lab=#net294}
N 13490 30 13490 50 {
lab=#net298}
N 13490 80 13490 310 {lab=GND}
N 13360 310 13490 310 {lab=GND}
N 13580 80 13610 80 {
lab=#net298}
N 13580 -20 13610 -20 {
lab=#net298}
N 13580 30 13580 80 {
lab=#net298}
N 13580 -20 13580 30 {
lab=#net298}
N 13650 -250 13650 -20 {lab=VDD}
N 13650 30 13650 50 {
lab=#net299}
N 13650 80 13650 310 {lab=GND}
N 13490 30 13580 30 {lab=#net298}
N 13490 10 13490 30 {
lab=#net298}
N 13490 310 13650 310 {lab=GND}
N 13490 -250 13650 -250 {lab=VDD}
N 13050 10 13050 30 {
lab=#net294}
N 12670 -110 13270 -110 {lab=#net1}
N 12670 190 13270 190 {lab=VCtrl}
N 13050 -250 13310 -250 {lab=VDD}
N 14020 80 14050 80 {
lab=#net300}
N 14020 -20 14050 -20 {
lab=#net300}
N 14020 30 14020 80 {
lab=#net300}
N 13910 80 13960 80 {
lab=GND}
N 13910 -20 13960 -20 {
lab=VDD}
N 13910 30 13910 50 {
lab=#net300}
N 13840 80 13870 80 {
lab=#net299}
N 13840 -20 13870 -20 {
lab=#net299}
N 13910 10 13910 30 {
lab=#net300}
N 13910 30 14020 30 {
lab=#net300}
N 14020 -20 14020 30 {
lab=#net300}
N 13840 30 13840 80 {
lab=#net299}
N 13960 80 13960 310 {
lab=GND}
N 13910 110 13910 230 {
lab=#net301}
N 13960 -250 14090 -250 {lab=VDD}
N 13910 -250 13910 -170 {lab=VDD}
N 14090 -250 14090 -20 {lab=VDD}
N 13870 -170 13870 -110 {lab=#net1}
N 13870 190 13870 260 {lab=VCtrl}
N 13650 310 13910 310 {lab=GND}
N 13910 -140 13910 -50 {lab=#net302}
N 13910 260 13910 310 {lab=GND}
N 13960 -250 13960 -20 {lab=VDD}
N 13910 -250 13960 -250 {lab=VDD}
N 13910 310 13960 310 {lab=GND}
N 13650 30 13840 30 {lab=#net299}
N 13840 -20 13840 30 {
lab=#net299}
N 14090 30 14090 50 {
lab=#net303}
N 14090 80 14090 310 {lab=GND}
N 13960 310 14090 310 {lab=GND}
N 14180 80 14210 80 {
lab=#net303}
N 14180 -20 14210 -20 {
lab=#net303}
N 14180 30 14180 80 {
lab=#net303}
N 14180 -20 14180 30 {
lab=#net303}
N 14250 -250 14250 -20 {lab=VDD}
N 14250 30 14250 50 {
lab=#net304}
N 14250 80 14250 310 {lab=GND}
N 14090 30 14180 30 {lab=#net303}
N 14090 10 14090 30 {
lab=#net303}
N 14090 310 14250 310 {lab=GND}
N 14090 -250 14250 -250 {lab=VDD}
N 14620 80 14650 80 {
lab=#net305}
N 14620 -20 14650 -20 {
lab=#net305}
N 14620 30 14620 80 {
lab=#net305}
N 14510 80 14560 80 {
lab=GND}
N 14510 -20 14560 -20 {
lab=VDD}
N 14510 30 14510 50 {
lab=#net305}
N 14440 80 14470 80 {
lab=#net304}
N 14440 -20 14470 -20 {
lab=#net304}
N 14510 10 14510 30 {
lab=#net305}
N 14510 30 14620 30 {
lab=#net305}
N 14620 -20 14620 30 {
lab=#net305}
N 14440 30 14440 80 {
lab=#net304}
N 14560 80 14560 310 {
lab=GND}
N 14510 110 14510 230 {
lab=#net306}
N 14560 -250 14690 -250 {lab=VDD}
N 14510 -250 14510 -170 {lab=VDD}
N 14690 -250 14690 -20 {lab=VDD}
N 14470 -170 14470 -110 {lab=#net1}
N 14470 190 14470 260 {lab=VCtrl}
N 14250 310 14510 310 {lab=GND}
N 14510 -140 14510 -50 {lab=#net307}
N 14510 260 14510 310 {lab=GND}
N 14560 -250 14560 -20 {lab=VDD}
N 14510 -250 14560 -250 {lab=VDD}
N 14510 310 14560 310 {lab=GND}
N 14250 30 14440 30 {lab=#net304}
N 14440 -20 14440 30 {
lab=#net304}
N 14690 30 14690 50 {
lab=#net308}
N 14690 80 14690 310 {lab=GND}
N 14560 310 14690 310 {lab=GND}
N 14780 80 14810 80 {
lab=#net308}
N 14780 -20 14810 -20 {
lab=#net308}
N 14780 30 14780 80 {
lab=#net308}
N 14780 -20 14780 30 {
lab=#net308}
N 14850 -250 14850 -20 {lab=VDD}
N 14850 30 14850 50 {
lab=#net309}
N 14850 80 14850 310 {lab=GND}
N 14690 30 14780 30 {lab=#net308}
N 14690 10 14690 30 {
lab=#net308}
N 14690 -250 14850 -250 {lab=VDD}
N 14250 10 14250 30 {
lab=#net304}
N 13870 -110 14470 -110 {lab=#net1}
N 13870 190 14470 190 {lab=VCtrl}
N 14250 -250 14510 -250 {lab=VDD}
N 13650 10 13650 30 {
lab=#net299}
N 13270 -110 13870 -110 {lab=#net1}
N 13270 190 13870 190 {lab=VCtrl}
N 13650 -250 13910 -250 {lab=VDD}
N 14690 310 14850 310 {lab=GND}
N 15220 80 15250 80 {
lab=#net310}
N 15220 -20 15250 -20 {
lab=#net310}
N 15220 30 15220 80 {
lab=#net310}
N 15110 80 15160 80 {
lab=GND}
N 15110 -20 15160 -20 {
lab=VDD}
N 15110 30 15110 50 {
lab=#net310}
N 15040 80 15070 80 {
lab=#net309}
N 15040 -20 15070 -20 {
lab=#net309}
N 15110 10 15110 30 {
lab=#net310}
N 15110 30 15220 30 {
lab=#net310}
N 15220 -20 15220 30 {
lab=#net310}
N 15040 30 15040 80 {
lab=#net309}
N 15160 80 15160 310 {
lab=GND}
N 15110 110 15110 230 {
lab=#net311}
N 15160 -250 15290 -250 {lab=VDD}
N 15110 -250 15110 -170 {lab=VDD}
N 15290 -250 15290 -20 {lab=VDD}
N 15070 -170 15070 -110 {lab=#net1}
N 15070 190 15070 260 {lab=VCtrl}
N 15110 -140 15110 -50 {lab=#net312}
N 15110 260 15110 310 {lab=GND}
N 15160 -250 15160 -20 {lab=VDD}
N 15110 -250 15160 -250 {lab=VDD}
N 15110 310 15160 310 {lab=GND}
N 14850 30 15040 30 {lab=#net309}
N 15040 -20 15040 30 {
lab=#net309}
N 15290 30 15290 50 {
lab=#net313}
N 15290 80 15290 310 {lab=GND}
N 15160 310 15290 310 {lab=GND}
N 15380 80 15410 80 {
lab=#net313}
N 15380 -20 15410 -20 {
lab=#net313}
N 15380 30 15380 80 {
lab=#net313}
N 15380 -20 15380 30 {
lab=#net313}
N 15450 -250 15450 -20 {lab=VDD}
N 15450 30 15450 50 {
lab=#net314}
N 15450 80 15450 310 {lab=GND}
N 15290 30 15380 30 {lab=#net313}
N 15290 10 15290 30 {
lab=#net313}
N 15290 310 15450 310 {lab=GND}
N 15290 -250 15450 -250 {lab=VDD}
N 15820 80 15850 80 {
lab=#net315}
N 15820 -20 15850 -20 {
lab=#net315}
N 15820 30 15820 80 {
lab=#net315}
N 15710 80 15760 80 {
lab=GND}
N 15710 -20 15760 -20 {
lab=VDD}
N 15710 30 15710 50 {
lab=#net315}
N 15640 80 15670 80 {
lab=#net314}
N 15640 -20 15670 -20 {
lab=#net314}
N 15710 10 15710 30 {
lab=#net315}
N 15710 30 15820 30 {
lab=#net315}
N 15820 -20 15820 30 {
lab=#net315}
N 15640 30 15640 80 {
lab=#net314}
N 15760 80 15760 310 {
lab=GND}
N 15710 110 15710 230 {
lab=#net316}
N 15760 -250 15890 -250 {lab=VDD}
N 15710 -250 15710 -170 {lab=VDD}
N 15890 -250 15890 -20 {lab=VDD}
N 15670 -170 15670 -110 {lab=#net1}
N 15670 190 15670 260 {lab=VCtrl}
N 15450 310 15710 310 {lab=GND}
N 15710 -140 15710 -50 {lab=#net317}
N 15710 260 15710 310 {lab=GND}
N 15760 -250 15760 -20 {lab=VDD}
N 15710 -250 15760 -250 {lab=VDD}
N 15710 310 15760 310 {lab=GND}
N 15450 30 15640 30 {lab=#net314}
N 15640 -20 15640 30 {
lab=#net314}
N 15890 30 15890 50 {
lab=#net318}
N 15890 80 15890 310 {lab=GND}
N 15760 310 15890 310 {lab=GND}
N 15980 80 16010 80 {
lab=#net318}
N 15980 -20 16010 -20 {
lab=#net318}
N 15980 30 15980 80 {
lab=#net318}
N 15980 -20 15980 30 {
lab=#net318}
N 16050 -250 16050 -20 {lab=VDD}
N 16050 30 16050 50 {
lab=#net319}
N 16050 80 16050 310 {lab=GND}
N 15890 30 15980 30 {lab=#net318}
N 15890 10 15890 30 {
lab=#net318}
N 15890 310 16050 310 {lab=GND}
N 15890 -250 16050 -250 {lab=VDD}
N 15450 10 15450 30 {
lab=#net314}
N 15070 -110 15670 -110 {lab=#net1}
N 15070 190 15670 190 {lab=VCtrl}
N 15450 -250 15710 -250 {lab=VDD}
N 16420 80 16450 80 {
lab=#net320}
N 16420 -20 16450 -20 {
lab=#net320}
N 16420 30 16420 80 {
lab=#net320}
N 16310 80 16360 80 {
lab=GND}
N 16310 -20 16360 -20 {
lab=VDD}
N 16310 30 16310 50 {
lab=#net320}
N 16240 80 16270 80 {
lab=#net319}
N 16240 -20 16270 -20 {
lab=#net319}
N 16310 10 16310 30 {
lab=#net320}
N 16310 30 16420 30 {
lab=#net320}
N 16420 -20 16420 30 {
lab=#net320}
N 16240 30 16240 80 {
lab=#net319}
N 16360 80 16360 310 {
lab=GND}
N 16310 110 16310 230 {
lab=#net321}
N 16360 -250 16490 -250 {lab=VDD}
N 16310 -250 16310 -170 {lab=VDD}
N 16490 -250 16490 -20 {lab=VDD}
N 16270 -170 16270 -110 {lab=#net1}
N 16270 190 16270 260 {lab=VCtrl}
N 16050 310 16310 310 {lab=GND}
N 16310 -140 16310 -50 {lab=#net322}
N 16310 260 16310 310 {lab=GND}
N 16360 -250 16360 -20 {lab=VDD}
N 16310 -250 16360 -250 {lab=VDD}
N 16310 310 16360 310 {lab=GND}
N 16050 30 16240 30 {lab=#net319}
N 16240 -20 16240 30 {
lab=#net319}
N 16490 30 16490 50 {
lab=#net323}
N 16490 80 16490 310 {lab=GND}
N 16360 310 16490 310 {lab=GND}
N 16580 80 16610 80 {
lab=#net323}
N 16580 -20 16610 -20 {
lab=#net323}
N 16580 30 16580 80 {
lab=#net323}
N 16580 -20 16580 30 {
lab=#net323}
N 16650 -250 16650 -20 {lab=VDD}
N 16650 30 16650 50 {
lab=#net324}
N 16650 80 16650 310 {lab=GND}
N 16490 30 16580 30 {lab=#net323}
N 16490 10 16490 30 {
lab=#net323}
N 16490 310 16650 310 {lab=GND}
N 16490 -250 16650 -250 {lab=VDD}
N 17020 80 17050 80 {
lab=#net325}
N 17020 -20 17050 -20 {
lab=#net325}
N 17020 30 17020 80 {
lab=#net325}
N 16910 80 16960 80 {
lab=GND}
N 16910 -20 16960 -20 {
lab=VDD}
N 16910 30 16910 50 {
lab=#net325}
N 16840 80 16870 80 {
lab=#net324}
N 16840 -20 16870 -20 {
lab=#net324}
N 16910 10 16910 30 {
lab=#net325}
N 16910 30 17020 30 {
lab=#net325}
N 17020 -20 17020 30 {
lab=#net325}
N 16840 30 16840 80 {
lab=#net324}
N 16960 80 16960 310 {
lab=GND}
N 16910 110 16910 230 {
lab=#net326}
N 16960 -250 17090 -250 {lab=VDD}
N 16910 -250 16910 -170 {lab=VDD}
N 17090 -250 17090 -20 {lab=VDD}
N 16870 -170 16870 -110 {lab=#net1}
N 16870 190 16870 260 {lab=VCtrl}
N 16650 310 16910 310 {lab=GND}
N 16910 -140 16910 -50 {lab=#net327}
N 16910 260 16910 310 {lab=GND}
N 16960 -250 16960 -20 {lab=VDD}
N 16910 -250 16960 -250 {lab=VDD}
N 16910 310 16960 310 {lab=GND}
N 16650 30 16840 30 {lab=#net324}
N 16840 -20 16840 30 {
lab=#net324}
N 17090 30 17090 50 {
lab=#net328}
N 17090 80 17090 310 {lab=GND}
N 16960 310 17090 310 {lab=GND}
N 17180 80 17210 80 {
lab=#net328}
N 17180 -20 17210 -20 {
lab=#net328}
N 17180 30 17180 80 {
lab=#net328}
N 17180 -20 17180 30 {
lab=#net328}
N 17250 -250 17250 -20 {lab=VDD}
N 17250 10 17250 50 {
lab=out}
N 17250 80 17250 310 {lab=GND}
N 17090 30 17180 30 {lab=#net328}
N 17090 10 17090 30 {
lab=#net328}
N 17090 -250 17250 -250 {lab=VDD}
N 16650 10 16650 30 {
lab=#net324}
N 16270 -110 16870 -110 {lab=#net1}
N 16270 190 16870 190 {lab=VCtrl}
N 16650 -250 16910 -250 {lab=VDD}
N 16050 10 16050 30 {
lab=#net319}
N 15670 -110 16270 -110 {lab=#net1}
N 15670 190 16270 190 {lab=VCtrl}
N 16050 -250 16310 -250 {lab=VDD}
N 17090 310 17250 310 {lab=GND}
N 14850 10 14850 30 {
lab=#net309}
N 14470 -110 15070 -110 {lab=#net1}
N 14850 -250 15110 -250 {lab=VDD}
N 14850 310 15110 310 {lab=GND}
N 14470 190 15070 190 {lab=VCtrl}
N 12450 10 12450 30 {
lab=#net250}
N 12070 -110 12670 -110 {lab=#net1}
N 12450 -250 12710 -250 {lab=VDD}
N 12290 310 12450 310 {lab=GND}
N 12450 310 12710 310 {lab=GND}
N 12070 190 12670 190 {lab=VCtrl}
N 11470 190 12070 190 {lab=VCtrl}
N 7640 10 7640 30 {
lab=#net170}
N 7260 190 7870 190 {lab=VCtrl}
N 7640 310 7910 310 {lab=GND}
N 7260 -110 7870 -110 {lab=#net1}
N 7640 -250 7910 -250 {lab=VDD}
N 7630 660 7900 660 {lab=VDD}
N 7470 660 7630 660 {lab=VDD}
N 7250 800 7860 800 {lab=#net11}
N 7250 1100 7860 1100 {lab=VCtrl}
N 7630 1220 7900 1220 {lab=GND}
N 7630 940 7830 940 {lab=#net130}
N 7630 920 7630 940 {
lab=#net130}
N -2600 30 -2600 70 {lab=VCtrl}
N -2790 70 -2600 70 {lab=VCtrl}
N -2790 30 -2790 70 {lab=VCtrl}
N -2600 -170 -2600 -0 {lab=VDD}
N -2790 -170 -2600 -170 {lab=VDD}
N -2310 -440 -2080 -440 {lab=GND}
N -2410 -440 -2370 -440 {lab=VSS}
N -3280 100 -3280 160 {lab=down}
N -3280 -40 -3280 20 {lab=up}
N -3760 -20 -3630 -20 {lab=#net329}
N -3960 -20 -3940 -20 {lab=in}
N -3960 -60 -3960 -20 {lab=in}
N -3960 -60 -3650 -60 {lab=in}
N -3650 -60 -3650 -40 {lab=in}
N -3650 -40 -3630 -40 {lab=in}
C {code_shown.sym} 10 -960 0 0 {name=MODEL only_toplevel=false format="tcleval( @value )"

value="
  .lib $::MODELS_NGSPICE/cornerCAP.lib cap_typ
  .lib cornerMOSlv.lib mos_tt
  .lib cornerRES.lib res_typ
"



}
C {lab_pin.sym} -2050 -250 0 0 {name=p2 lab=VDD}
C {devices/ammeter.sym} -1920 -20 0 0 {name=Vmycc
l=0.2u}
C {sg13g2_pr/sg13_lv_pmos.sym} -1940 -170 0 0 {name=M14
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -1940 260 0 0 {name=M21
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {code_shown.sym} 10 -810 0 0 {name=NGSPICE only_toplevel=true 
value="tcleval(
* Note! Since this script is wrapped in tcleval,
* code that is written in square brackets are in TCL scripting language
*
* The rest of the code is in spice scripting language

* Disabled because of computational cost/memory usage for big designs
* Save FET params like ids, gm, gds, vth, vgs, vdss, vds, cgg, cgsol, cgdol
* for annotation later (easier debugging and analysis)
* .include [file rootname [file tail [xschem get current_name]]].save

* Customized code to include spice model for simulation
.include sg13g2_stdcell.spice

.control
  * save all
  save v(up) v(down) v(rstn) v(delaycheckin) v(delaycheckout) v(Vctrl) v(in) v(out) v(vdd)

  tran 50p 4000n

  write [file rootname [file tail [xschem get current_name]]].raw

  * I DID NOT USE THE BELOW, because if an error occured we wouldn't know
  * Automatically close the popup after simulation complete *
  * quit
.endc
)"}
C {devices/vsource.sym} -2260 -470 0 0 {name=V2 value="PWL(0ns 0 0.1ns 1.2)"}
C {gnd.sym} -2260 -440 0 0 {name=l2 lab=GND}
C {lab_pin.sym} -2260 -500 2 0 {name=p13 lab=VDD}
C {devices/vsource.sym} -1970 80 0 0 {name=V1 value="PULSE(0 1.2 5n 100p 100p 10ns 20ns)"}
C {devices/lab_pin.sym} -1840 30 2 0 {name=p3 sig_type=std_logic lab=in}
C {gnd.sym} -1970 110 0 0 {name=l1 lab=GND}
C {lab_pin.sym} -2410 -440 0 0 {name=p4 lab=VSS}
C {res.sym} -2340 -440 1 0 {name=R1
value=0.00001
footprint=1206
device=resistor
m=1}
C {gnd.sym} -2790 300 0 0 {name=l4 lab=GND}
C {devices/launcher.sym} 60 -1020 0 0 {name=h1
descr="Ctrl + Left Click to Annotate and load waves" 
tclcommand="
xschem annotate_op
xschem raw_read $netlist_dir/[file rootname [file tail [xschem get current_name]]].raw tran
xschem setprop rect 2 0 fullxzoom
"
}
C {launcher.sym} 62.33626929682691 -1080 0 0 {name=h3
descr="Ctrl + Left Click to Simulate NGSPICE"
tclcommand="
# Setup the default simulation commands if not already set up
# for example by already launched simulations.
set_sim_defaults
puts $sim(spice,1,cmd) 

# Change the Xyce command. In the spice category there are currently
# 5 commands (0, 1, 2, 3, 4). Command 3 is the Xyce batch
# you can get the number by querying $sim(spice,n)
set sim(spice,1,cmd) \{ngspice  \\"$N\\" -a\}

# change the simulator to be used (Xyce)
set sim(spice,default) 0

# Create FET and BIP .save file
mkdir -p $netlist_dir
write_data [save_params] $netlist_dir/[file rootname [file tail [xschem get current_name]]].save

# Generate netlist
xschem netlist

# Run simulation
simulate

# While its nice to be able to wait for the simulation to complete,
# then automatically annotate and load waves,
# The following waits for the simulation popup to close,
# so if its not closed, then it will keep waiting

# set id1 [simulate]
# vwait execute(exitcode,$id1)
# put "done!"

"
}
C {lab_pin.sym} -2560 70 2 0 {name=p6 lab=VCtrl}
C {sg13g2_pr/sg13_lv_nmos.sym} -2810 140 0 0 {name=M27
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -2810 0 0 0 {name=M28
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -2830 140 0 0 {name=p7 lab=down}
C {lab_pin.sym} -2970 0 0 0 {name=p8 lab=up}
C {sg13g2_stdcells/sg13g2_inv_1.sym} -2930 0 0 0 {name=x7 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {isource.sym} -3040 200 0 0 {name=Il1 value=1u}
C {lab_pin.sym} -2790 -170 0 0 {name=p9 lab=VDD}
C {capa.sym} -2600 100 0 0 {name=C1
m=1
value=2p
footprint=1206
device="ceramic capacitor"}
C {gnd.sym} -2600 130 0 0 {name=l8 lab=GND}
C {sg13g2_stdcells/sg13g2_dfrbp_1.sym} -3540 -20 0 0 {name=x53 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_dfrbp_1.sym} -3540 140 2 1 {name=x1 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} -3630 140 0 0 {name=p14 lab=VDD}
C {lab_pin.sym} -3280 -40 2 0 {name=p10 lab=up}
C {lab_pin.sym} -3280 160 2 0 {name=p12 lab=down}
C {devices/lab_pin.sym} -3960 -60 0 0 {name=p15 sig_type=std_logic lab=in}
C {devices/lab_pin.sym} -3630 160 0 0 {name=p16 sig_type=std_logic lab=out}
C {sg13g2_pr/sg13_lv_pmos.sym} -2810 -120 0 0 {name=M29
l=0.4u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -2810 270 0 0 {name=M30
l=0.4u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -3060 270 0 0 {name=M31
l=0.4u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_pin.sym} -3040 170 0 0 {name=p17 lab=VDD}
C {sg13g2_pr/sg13_lv_pmos.sym} -3030 -110 0 0 {name=M32
l=0.4u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {isource.sym} -3010 -50 0 0 {name=Il2 value=1u}
C {gnd.sym} -3010 -20 0 0 {name=l9 lab=GND}
C {devices/lab_pin.sym} 17240 940 2 0 {name=p18 sig_type=std_logic lab=delaycheckout}
C {lab_pin.sym} -2050 660 0 0 {name=p19 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -1730 990 0 0 {name=M33
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -1730 1170 0 0 {name=M34
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {devices/ammeter.sym} -1920 890 0 0 {name=Vmycc1
l=0.2u}
C {sg13g2_pr/sg13_lv_pmos.sym} -1730 740 0 0 {name=M35
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1940 740 0 0 {name=M36
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -1550 990 0 0 {name=M37
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -1940 1170 0 0 {name=M38
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1730 890 0 0 {name=M39
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1550 890 0 0 {name=M40
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {devices/vsource.sym} -1970 990 0 0 {name=V3 value="PULSE(0 1.2 5n 100p 100p 20ns 100ns)"}
C {gnd.sym} -1970 1020 0 0 {name=l10 lab=GND}
C {gnd.sym} -1660 1220 0 0 {name=l11 lab=GND}
C {devices/lab_pin.sym} -1900 940 2 0 {name=p20 sig_type=std_logic lab=delaycheckin}
C {lab_pin.sym} -2040 260 2 0 {name=p5 lab=VCtrl}
C {lab_pin.sym} -2040 1170 2 0 {name=p21 lab=VCtrl}
C {sg13g2_pr/sg13_lv_nmos.sym} -1390 990 0 0 {name=M24
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1390 890 0 0 {name=M26
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -1130 990 0 0 {name=M41
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -1130 1170 0 0 {name=M42
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1130 740 0 0 {name=M43
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -950 990 0 0 {name=M44
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1130 890 0 0 {name=M45
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -950 890 0 0 {name=M46
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} -1060 1220 0 0 {name=l12 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} -790 990 0 0 {name=M47
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -790 890 0 0 {name=M48
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -530 990 0 0 {name=M49
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -530 1170 0 0 {name=M50
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -530 740 0 0 {name=M51
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -350 990 0 0 {name=M52
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -530 890 0 0 {name=M53
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -350 890 0 0 {name=M54
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} -460 1220 0 0 {name=l13 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} -190 990 0 0 {name=M55
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -190 890 0 0 {name=M56
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 70 990 0 0 {name=M57
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 70 1170 0 0 {name=M58
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 70 740 0 0 {name=M229
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 250 990 0 0 {name=M230
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 70 890 0 0 {name=M231
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 250 890 0 0 {name=M232
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 140 1220 0 0 {name=l14 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 410 990 0 0 {name=M233
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 410 890 0 0 {name=M234
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -1720 80 0 0 {name=M1
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -1720 260 0 0 {name=M2
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1720 -170 0 0 {name=M3
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -1540 80 0 0 {name=M4
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1720 -20 0 0 {name=M5
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1540 -20 0 0 {name=M6
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} -1650 310 0 0 {name=l3 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} -1380 80 0 0 {name=M7
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1380 -20 0 0 {name=M8
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -1120 80 0 0 {name=M9
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -1120 260 0 0 {name=M10
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1120 -170 0 0 {name=M11
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -940 80 0 0 {name=M12
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1120 -20 0 0 {name=M13
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -940 -20 0 0 {name=M15
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} -1050 310 0 0 {name=l5 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} -780 80 0 0 {name=M16
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -780 -20 0 0 {name=M17
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -520 80 0 0 {name=M18
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -520 260 0 0 {name=M19
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -520 -170 0 0 {name=M20
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -340 80 0 0 {name=M22
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -520 -20 0 0 {name=M23
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -340 -20 0 0 {name=M25
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} -450 310 0 0 {name=l6 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} -180 80 0 0 {name=M59
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -180 -20 0 0 {name=M60
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 80 80 0 0 {name=M61
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 80 260 0 0 {name=M62
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 80 -170 0 0 {name=M63
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 260 80 0 0 {name=M64
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 80 -20 0 0 {name=M65
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 260 -20 0 0 {name=M66
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 150 310 0 0 {name=l7 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 420 80 0 0 {name=M67
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 420 -20 0 0 {name=M68
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {devices/lab_pin.sym} 17250 30 2 0 {name=p22 sig_type=std_logic lab=out}
C {sg13g2_pr/sg13_lv_nmos.sym} 670 990 0 0 {name=M69
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 670 1170 0 0 {name=M70
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 670 740 0 0 {name=M71
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 850 990 0 0 {name=M72
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 670 890 0 0 {name=M73
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 850 890 0 0 {name=M74
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 740 1220 0 0 {name=l15 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 1010 990 0 0 {name=M75
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1010 890 0 0 {name=M76
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1270 990 0 0 {name=M77
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1270 1170 0 0 {name=M78
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1270 740 0 0 {name=M79
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1450 990 0 0 {name=M80
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1270 890 0 0 {name=M81
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1450 890 0 0 {name=M82
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 1340 1220 0 0 {name=l16 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 1610 990 0 0 {name=M83
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1610 890 0 0 {name=M84
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1870 990 0 0 {name=M85
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1870 1170 0 0 {name=M86
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1870 740 0 0 {name=M87
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2050 990 0 0 {name=M88
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1870 890 0 0 {name=M89
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2050 890 0 0 {name=M90
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 1940 1220 0 0 {name=l17 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 2210 990 0 0 {name=M91
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2210 890 0 0 {name=M92
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2470 990 0 0 {name=M93
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2470 1170 0 0 {name=M94
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2470 740 0 0 {name=M95
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2650 990 0 0 {name=M96
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2470 890 0 0 {name=M97
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2650 890 0 0 {name=M98
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 2540 1220 0 0 {name=l18 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 2810 990 0 0 {name=M99
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2810 890 0 0 {name=M100
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 680 80 0 0 {name=M101
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 680 260 0 0 {name=M102
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 680 -170 0 0 {name=M103
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 860 80 0 0 {name=M104
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 680 -20 0 0 {name=M105
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 860 -20 0 0 {name=M106
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 750 310 0 0 {name=l19 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 1020 80 0 0 {name=M107
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1020 -20 0 0 {name=M108
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1280 80 0 0 {name=M109
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1280 260 0 0 {name=M110
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1280 -170 0 0 {name=M111
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1460 80 0 0 {name=M112
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1280 -20 0 0 {name=M113
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1460 -20 0 0 {name=M114
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 1350 310 0 0 {name=l20 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 1620 80 0 0 {name=M115
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1620 -20 0 0 {name=M116
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1880 80 0 0 {name=M117
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1880 260 0 0 {name=M118
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1880 -170 0 0 {name=M119
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2060 80 0 0 {name=M120
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1880 -20 0 0 {name=M121
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2060 -20 0 0 {name=M122
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 1950 310 0 0 {name=l21 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 2220 80 0 0 {name=M123
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2220 -20 0 0 {name=M124
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2480 80 0 0 {name=M125
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2480 260 0 0 {name=M126
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2480 -170 0 0 {name=M127
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2660 80 0 0 {name=M128
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2480 -20 0 0 {name=M129
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2660 -20 0 0 {name=M130
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 2550 310 0 0 {name=l22 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 2820 80 0 0 {name=M131
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2820 -20 0 0 {name=M132
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3070 990 0 0 {name=M133
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3070 1170 0 0 {name=M134
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3070 740 0 0 {name=M135
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3250 990 0 0 {name=M136
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3070 890 0 0 {name=M137
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3250 890 0 0 {name=M138
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 3140 1220 0 0 {name=l23 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 3410 990 0 0 {name=M139
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3410 890 0 0 {name=M140
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3670 990 0 0 {name=M141
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3670 1170 0 0 {name=M142
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3670 740 0 0 {name=M143
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3850 990 0 0 {name=M144
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3670 890 0 0 {name=M145
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3850 890 0 0 {name=M146
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 3740 1220 0 0 {name=l24 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 4010 990 0 0 {name=M147
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4010 890 0 0 {name=M148
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4270 990 0 0 {name=M149
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4270 1170 0 0 {name=M150
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4270 740 0 0 {name=M151
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4450 990 0 0 {name=M152
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4270 890 0 0 {name=M153
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4450 890 0 0 {name=M154
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 4340 1220 0 0 {name=l25 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 4610 990 0 0 {name=M155
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4610 890 0 0 {name=M156
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4870 990 0 0 {name=M157
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4870 1170 0 0 {name=M158
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4870 740 0 0 {name=M159
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 5050 990 0 0 {name=M160
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4870 890 0 0 {name=M161
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 5050 890 0 0 {name=M162
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 4940 1220 0 0 {name=l26 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 5210 990 0 0 {name=M163
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 5210 890 0 0 {name=M164
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 5470 990 0 0 {name=M165
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 5470 1170 0 0 {name=M166
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 5470 740 0 0 {name=M167
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 5650 990 0 0 {name=M168
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 5470 890 0 0 {name=M169
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 5650 890 0 0 {name=M170
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 5540 1220 0 0 {name=l27 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 5810 990 0 0 {name=M171
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 5810 890 0 0 {name=M172
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 6070 990 0 0 {name=M173
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 6070 1170 0 0 {name=M174
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6070 740 0 0 {name=M175
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 6250 990 0 0 {name=M176
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6070 890 0 0 {name=M177
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6250 890 0 0 {name=M178
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 6140 1220 0 0 {name=l28 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 6410 990 0 0 {name=M179
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6410 890 0 0 {name=M180
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 6670 990 0 0 {name=M181
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 6670 1170 0 0 {name=M182
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6670 740 0 0 {name=M183
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 6850 990 0 0 {name=M184
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6670 890 0 0 {name=M185
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6850 890 0 0 {name=M186
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 6740 1220 0 0 {name=l29 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 7010 990 0 0 {name=M187
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7010 890 0 0 {name=M188
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 7270 990 0 0 {name=M189
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 7270 1170 0 0 {name=M190
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7270 740 0 0 {name=M191
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 7450 990 0 0 {name=M192
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7270 890 0 0 {name=M193
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7450 890 0 0 {name=M194
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 7340 1220 0 0 {name=l30 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 7610 990 0 0 {name=M195
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7610 890 0 0 {name=M196
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3080 80 0 0 {name=M197
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3080 260 0 0 {name=M198
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3080 -170 0 0 {name=M199
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3260 80 0 0 {name=M200
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3080 -20 0 0 {name=M201
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3260 -20 0 0 {name=M202
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 3150 310 0 0 {name=l31 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 3420 80 0 0 {name=M203
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3420 -20 0 0 {name=M204
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3680 80 0 0 {name=M205
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3680 260 0 0 {name=M206
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3680 -170 0 0 {name=M207
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3860 80 0 0 {name=M208
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3680 -20 0 0 {name=M209
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3860 -20 0 0 {name=M210
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 3750 310 0 0 {name=l32 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 4020 80 0 0 {name=M211
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4020 -20 0 0 {name=M212
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4280 80 0 0 {name=M213
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4280 260 0 0 {name=M214
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4280 -170 0 0 {name=M215
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4460 80 0 0 {name=M216
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4280 -20 0 0 {name=M217
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4460 -20 0 0 {name=M218
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 4350 310 0 0 {name=l33 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 4620 80 0 0 {name=M219
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4620 -20 0 0 {name=M220
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4880 80 0 0 {name=M221
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4880 260 0 0 {name=M222
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4880 -170 0 0 {name=M223
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 5060 80 0 0 {name=M224
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4880 -20 0 0 {name=M225
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 5060 -20 0 0 {name=M226
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 4950 310 0 0 {name=l34 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 5220 80 0 0 {name=M227
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 5220 -20 0 0 {name=M228
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 5480 80 0 0 {name=M235
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 5480 260 0 0 {name=M236
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 5480 -170 0 0 {name=M237
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 5660 80 0 0 {name=M238
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 5480 -20 0 0 {name=M239
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 5660 -20 0 0 {name=M240
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 5550 310 0 0 {name=l35 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 5820 80 0 0 {name=M241
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 5820 -20 0 0 {name=M242
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 6080 80 0 0 {name=M243
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 6080 260 0 0 {name=M244
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6080 -170 0 0 {name=M245
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 6260 80 0 0 {name=M246
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6080 -20 0 0 {name=M247
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6260 -20 0 0 {name=M248
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 6150 310 0 0 {name=l36 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 6420 80 0 0 {name=M249
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6420 -20 0 0 {name=M250
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 6680 80 0 0 {name=M251
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 6680 260 0 0 {name=M252
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6680 -170 0 0 {name=M253
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 6860 80 0 0 {name=M254
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6680 -20 0 0 {name=M255
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6860 -20 0 0 {name=M256
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 6750 310 0 0 {name=l37 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 7020 80 0 0 {name=M257
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7020 -20 0 0 {name=M258
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 7280 80 0 0 {name=M259
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 7280 260 0 0 {name=M260
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7280 -170 0 0 {name=M261
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 7460 80 0 0 {name=M262
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7280 -20 0 0 {name=M263
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7460 -20 0 0 {name=M264
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 7350 310 0 0 {name=l38 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 7620 80 0 0 {name=M265
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7620 -20 0 0 {name=M266
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 7880 990 0 0 {name=M267
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 7880 1170 0 0 {name=M268
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7880 740 0 0 {name=M269
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 8060 990 0 0 {name=M270
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7880 890 0 0 {name=M271
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8060 890 0 0 {name=M272
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 7950 1220 0 0 {name=l39 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 8220 990 0 0 {name=M273
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8220 890 0 0 {name=M274
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 8480 990 0 0 {name=M275
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 8480 1170 0 0 {name=M276
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8480 740 0 0 {name=M277
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 8660 990 0 0 {name=M278
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8480 890 0 0 {name=M279
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8660 890 0 0 {name=M280
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 8550 1220 0 0 {name=l40 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 8820 990 0 0 {name=M281
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8820 890 0 0 {name=M282
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 9080 990 0 0 {name=M283
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 9080 1170 0 0 {name=M284
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9080 740 0 0 {name=M285
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 9260 990 0 0 {name=M286
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9080 890 0 0 {name=M287
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9260 890 0 0 {name=M288
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 9150 1220 0 0 {name=l41 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 9420 990 0 0 {name=M289
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9420 890 0 0 {name=M290
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 9680 990 0 0 {name=M291
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 9680 1170 0 0 {name=M292
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9680 740 0 0 {name=M293
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 9860 990 0 0 {name=M294
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9680 890 0 0 {name=M295
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9860 890 0 0 {name=M296
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 9750 1220 0 0 {name=l42 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 10020 990 0 0 {name=M297
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10020 890 0 0 {name=M298
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 7890 80 0 0 {name=M299
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 7890 260 0 0 {name=M300
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7890 -170 0 0 {name=M301
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 8070 80 0 0 {name=M302
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7890 -20 0 0 {name=M303
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8070 -20 0 0 {name=M304
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 7960 310 0 0 {name=l43 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 8230 80 0 0 {name=M305
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8230 -20 0 0 {name=M306
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 8490 80 0 0 {name=M307
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 8490 260 0 0 {name=M308
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8490 -170 0 0 {name=M309
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 8670 80 0 0 {name=M310
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8490 -20 0 0 {name=M311
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8670 -20 0 0 {name=M312
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 8560 310 0 0 {name=l44 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 8830 80 0 0 {name=M313
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8830 -20 0 0 {name=M314
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 9090 80 0 0 {name=M315
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 9090 260 0 0 {name=M316
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9090 -170 0 0 {name=M317
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 9270 80 0 0 {name=M318
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9090 -20 0 0 {name=M319
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9270 -20 0 0 {name=M320
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 9160 310 0 0 {name=l45 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 9430 80 0 0 {name=M321
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9430 -20 0 0 {name=M322
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 9690 80 0 0 {name=M323
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 9690 260 0 0 {name=M324
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9690 -170 0 0 {name=M325
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 9870 80 0 0 {name=M326
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9690 -20 0 0 {name=M327
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9870 -20 0 0 {name=M328
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 9760 310 0 0 {name=l46 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 10030 80 0 0 {name=M329
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10030 -20 0 0 {name=M330
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 10280 990 0 0 {name=M331
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 10280 1170 0 0 {name=M332
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10280 740 0 0 {name=M333
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 10460 990 0 0 {name=M334
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10280 890 0 0 {name=M335
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10460 890 0 0 {name=M336
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 10350 1220 0 0 {name=l47 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 10620 990 0 0 {name=M337
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10620 890 0 0 {name=M338
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 10880 990 0 0 {name=M339
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 10880 1170 0 0 {name=M340
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10880 740 0 0 {name=M341
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 11060 990 0 0 {name=M342
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10880 890 0 0 {name=M343
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11060 890 0 0 {name=M344
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 10950 1220 0 0 {name=l48 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 11220 990 0 0 {name=M345
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11220 890 0 0 {name=M346
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 11480 990 0 0 {name=M347
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 11480 1170 0 0 {name=M348
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11480 740 0 0 {name=M349
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 11660 990 0 0 {name=M350
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11480 890 0 0 {name=M351
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11660 890 0 0 {name=M352
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 11550 1220 0 0 {name=l49 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 11820 990 0 0 {name=M353
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11820 890 0 0 {name=M354
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 12080 990 0 0 {name=M355
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 12080 1170 0 0 {name=M356
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 12080 740 0 0 {name=M357
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 12260 990 0 0 {name=M358
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 12080 890 0 0 {name=M359
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 12260 890 0 0 {name=M360
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 12150 1220 0 0 {name=l50 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 12420 990 0 0 {name=M361
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 12420 890 0 0 {name=M362
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 10290 80 0 0 {name=M363
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 10290 260 0 0 {name=M364
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10290 -170 0 0 {name=M365
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 10470 80 0 0 {name=M366
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10290 -20 0 0 {name=M367
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10470 -20 0 0 {name=M368
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 10360 310 0 0 {name=l51 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 10630 80 0 0 {name=M369
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10630 -20 0 0 {name=M370
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 10890 80 0 0 {name=M371
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 10890 260 0 0 {name=M372
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10890 -170 0 0 {name=M373
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 11070 80 0 0 {name=M374
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10890 -20 0 0 {name=M375
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11070 -20 0 0 {name=M376
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 10960 310 0 0 {name=l52 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 11230 80 0 0 {name=M377
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11230 -20 0 0 {name=M378
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 11490 80 0 0 {name=M379
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 11490 260 0 0 {name=M380
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11490 -170 0 0 {name=M381
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 11670 80 0 0 {name=M382
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11490 -20 0 0 {name=M383
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11670 -20 0 0 {name=M384
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 11560 310 0 0 {name=l53 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 11830 80 0 0 {name=M385
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11830 -20 0 0 {name=M386
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 12090 80 0 0 {name=M387
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 12090 260 0 0 {name=M388
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 12090 -170 0 0 {name=M389
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 12270 80 0 0 {name=M390
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 12090 -20 0 0 {name=M391
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 12270 -20 0 0 {name=M392
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 12160 310 0 0 {name=l54 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 12430 80 0 0 {name=M393
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 12430 -20 0 0 {name=M394
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 12680 990 0 0 {name=M395
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 12680 1170 0 0 {name=M396
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 12680 740 0 0 {name=M397
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 12860 990 0 0 {name=M398
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 12680 890 0 0 {name=M399
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 12860 890 0 0 {name=M400
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 12750 1220 0 0 {name=l55 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 13020 990 0 0 {name=M401
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 13020 890 0 0 {name=M402
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 13280 990 0 0 {name=M403
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 13280 1170 0 0 {name=M404
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 13280 740 0 0 {name=M405
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 13460 990 0 0 {name=M406
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 13280 890 0 0 {name=M407
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 13460 890 0 0 {name=M408
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 13350 1220 0 0 {name=l56 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 13620 990 0 0 {name=M409
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 13620 890 0 0 {name=M410
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 13880 990 0 0 {name=M411
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 13880 1170 0 0 {name=M412
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 13880 740 0 0 {name=M413
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 14060 990 0 0 {name=M414
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 13880 890 0 0 {name=M415
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 14060 890 0 0 {name=M416
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 13950 1220 0 0 {name=l57 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 14220 990 0 0 {name=M417
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 14220 890 0 0 {name=M418
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 14480 990 0 0 {name=M419
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 14480 1170 0 0 {name=M420
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 14480 740 0 0 {name=M421
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 14660 990 0 0 {name=M422
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 14480 890 0 0 {name=M423
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 14660 890 0 0 {name=M424
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 14550 1220 0 0 {name=l58 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 14820 990 0 0 {name=M425
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 14820 890 0 0 {name=M426
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 15080 990 0 0 {name=M427
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 15080 1170 0 0 {name=M428
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 15080 740 0 0 {name=M429
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 15260 990 0 0 {name=M430
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 15080 890 0 0 {name=M431
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 15260 890 0 0 {name=M432
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 15150 1220 0 0 {name=l59 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 15420 990 0 0 {name=M433
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 15420 890 0 0 {name=M434
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 15680 990 0 0 {name=M435
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 15680 1170 0 0 {name=M436
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 15680 740 0 0 {name=M437
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 15860 990 0 0 {name=M438
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 15680 890 0 0 {name=M439
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 15860 890 0 0 {name=M440
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 15750 1220 0 0 {name=l60 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 16020 990 0 0 {name=M441
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 16020 890 0 0 {name=M442
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 16280 990 0 0 {name=M443
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 16280 1170 0 0 {name=M444
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 16280 740 0 0 {name=M445
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 16460 990 0 0 {name=M446
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 16280 890 0 0 {name=M447
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 16460 890 0 0 {name=M448
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 16350 1220 0 0 {name=l61 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 16620 990 0 0 {name=M449
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 16620 890 0 0 {name=M450
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 16880 990 0 0 {name=M451
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 16880 1170 0 0 {name=M452
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 16880 740 0 0 {name=M453
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 17060 990 0 0 {name=M454
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 16880 890 0 0 {name=M455
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 17060 890 0 0 {name=M456
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 16950 1220 0 0 {name=l62 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 17220 990 0 0 {name=M457
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 17220 890 0 0 {name=M458
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 12690 80 0 0 {name=M459
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 12690 260 0 0 {name=M460
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 12690 -170 0 0 {name=M461
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 12870 80 0 0 {name=M462
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 12690 -20 0 0 {name=M463
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 12870 -20 0 0 {name=M464
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 12760 310 0 0 {name=l63 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 13030 80 0 0 {name=M465
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 13030 -20 0 0 {name=M466
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 13290 80 0 0 {name=M467
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 13290 260 0 0 {name=M468
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 13290 -170 0 0 {name=M469
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 13470 80 0 0 {name=M470
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 13290 -20 0 0 {name=M471
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 13470 -20 0 0 {name=M472
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 13360 310 0 0 {name=l64 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 13630 80 0 0 {name=M473
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 13630 -20 0 0 {name=M474
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 13890 80 0 0 {name=M475
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 13890 260 0 0 {name=M476
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 13890 -170 0 0 {name=M477
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 14070 80 0 0 {name=M478
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 13890 -20 0 0 {name=M479
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 14070 -20 0 0 {name=M480
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 13960 310 0 0 {name=l65 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 14230 80 0 0 {name=M481
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 14230 -20 0 0 {name=M482
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 14490 80 0 0 {name=M483
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 14490 260 0 0 {name=M484
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 14490 -170 0 0 {name=M485
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 14670 80 0 0 {name=M486
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 14490 -20 0 0 {name=M487
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 14670 -20 0 0 {name=M488
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 14560 310 0 0 {name=l66 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 14830 80 0 0 {name=M489
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 14830 -20 0 0 {name=M490
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 15090 80 0 0 {name=M491
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 15090 260 0 0 {name=M492
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 15090 -170 0 0 {name=M493
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 15270 80 0 0 {name=M494
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 15090 -20 0 0 {name=M495
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 15270 -20 0 0 {name=M496
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 15160 310 0 0 {name=l67 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 15430 80 0 0 {name=M497
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 15430 -20 0 0 {name=M498
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 15690 80 0 0 {name=M499
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 15690 260 0 0 {name=M500
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 15690 -170 0 0 {name=M501
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 15870 80 0 0 {name=M502
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 15690 -20 0 0 {name=M503
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 15870 -20 0 0 {name=M504
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 15760 310 0 0 {name=l68 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 16030 80 0 0 {name=M505
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 16030 -20 0 0 {name=M506
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 16290 80 0 0 {name=M507
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 16290 260 0 0 {name=M508
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 16290 -170 0 0 {name=M509
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 16470 80 0 0 {name=M510
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 16290 -20 0 0 {name=M511
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 16470 -20 0 0 {name=M512
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 16360 310 0 0 {name=l69 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 16630 80 0 0 {name=M513
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 16630 -20 0 0 {name=M514
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 16890 80 0 0 {name=M515
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 16890 260 0 0 {name=M516
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 16890 -170 0 0 {name=M517
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 17070 80 0 0 {name=M518
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 16890 -20 0 0 {name=M519
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 17070 -20 0 0 {name=M520
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 16960 310 0 0 {name=l70 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 17230 80 0 0 {name=M521
l=0.13u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 17230 -20 0 0 {name=M522
l=0.13u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {devices/vsource.sym} -2080 -470 0 0 {name=V4 value="PWL(0ns 0 100ns 0 100.1ns 1.2)"}
C {gnd.sym} -2080 -440 0 0 {name=l71 lab=GND}
C {lab_pin.sym} -2080 -500 2 0 {name=p1 lab=rstn}
C {lab_pin.sym} -2560 0 2 0 {name=p23 lab=rstn}
C {sg13g2_pr/sg13_lv_pmos.sym} -2580 0 0 1 {name=M523
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_stdcells/sg13g2_nand3_1.sym} -3340 60 2 0 {name=x19 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} -3280 60 2 0 {name=p24 lab=rstn}
C {sg13g2_stdcells/sg13g2_dfrbp_1.sym} -3850 0 0 0 {name=x2 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} -3940 20 0 0 {name=p25 lab=rstn}
C {lab_pin.sym} -3940 0 0 0 {name=p26 lab=VDD}
