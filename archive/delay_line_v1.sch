v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
B 2 -10 -1540 790 -1140 {flags=graph
y1=-0.72010816
y2=1.7709405
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.8006121e-06
x2=1.8117015e-06
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color="21 8 5"
node="out
in
vdd"
divx=5
hilight_wave=2}
B 2 -10 -1970 790 -1570 {flags=graph
y1=-0.32531444
y2=1.6675244
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.8006121e-06
x2=1.8117015e-06
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
divx=5
color="4 7"
node="up
down"}
B 2 -10 -2410 790 -2010 {flags=graph
y1=-0.27153961
y2=1.2589606
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.8006121e-06
x2=1.8117015e-06
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
divx=5
color=20
node=VCtrl}
B 2 -10 -2840 790 -2440 {flags=graph
y1=-0.72010816
y2=1.7709405
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.8006121e-06
x2=1.8117015e-06
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color="8 21"
node="delaycheckin
delaycheckout"
divx=5
hilight_wave=1}
T {Ctrl-Click to execute launcher} 10 -1120 0 0 0.3 0.3 {layer=11}
N -1600 80 -1570 80 {
lab=#net1}
N -1600 -20 -1570 -20 {
lab=#net1}
N -1600 30 -1600 80 {
lab=#net1}
N -1710 80 -1660 80 {
lab=GND}
N -1710 -20 -1660 -20 {
lab=VDD}
N -1710 30 -1710 50 {
lab=#net1}
N -1780 80 -1750 80 {
lab=in}
N -1780 -20 -1750 -20 {
lab=in}
N -1710 10 -1710 30 {
lab=#net1}
N -1710 30 -1600 30 {
lab=#net1}
N -1600 -20 -1600 30 {
lab=#net1}
N -1780 30 -1780 80 {
lab=in}
N -1660 80 -1660 310 {
lab=GND}
N -1710 110 -1710 230 {
lab=#net2}
N -1660 -250 -1530 -250 {lab=VDD}
N -1710 -250 -1710 -170 {lab=VDD}
N -1530 -250 -1530 -20 {lab=VDD}
N -1750 -170 -1750 -110 {lab=#net3}
N -1750 190 -1750 260 {lab=VCtrl}
N -1920 -250 -1920 -170 {lab=VDD}
N -1960 -170 -1960 -110 {lab=#net3}
N -1920 -250 -1710 -250 {lab=VDD}
N -1920 310 -1710 310 {lab=GND}
N -1920 -110 -1920 -50 {lab=#net3}
N -2050 -250 -1920 -250 {lab=VDD}
N -1960 -110 -1920 -110 {lab=#net3}
N -1920 -140 -1920 -110 {lab=#net3}
N -1920 -110 -1750 -110 {lab=#net3}
N -1920 10 -1920 230 {lab=#net4}
N -1710 -140 -1710 -50 {lab=#net5}
N -1710 260 -1710 310 {lab=GND}
N -1920 260 -1920 310 {lab=GND}
N -1660 -250 -1660 -20 {lab=VDD}
N -1710 -250 -1660 -250 {lab=VDD}
N -1710 310 -1660 310 {lab=GND}
N -1530 30 -1530 50 {
lab=#net6}
N -1530 310 -1280 310 {lab=GND}
N -2300 -300 -2210 -300 {lab=VSS}
N -2290 -360 -2210 -360 {lab=GND}
N -1960 190 -1750 190 {lab=VCtrl}
N -1960 190 -1960 260 {lab=VCtrl}
N -1970 30 -1780 30 {lab=in}
N -1970 30 -1970 50 {lab=in}
N -1780 -20 -1780 30 {
lab=in}
N -2290 190 -2290 260 {lab=#net7}
N -1170 80 -1140 80 {
lab=#net8}
N -1170 -20 -1140 -20 {
lab=#net8}
N -1170 30 -1170 80 {
lab=#net8}
N -1280 80 -1230 80 {
lab=GND}
N -1280 -20 -1230 -20 {
lab=VDD}
N -1280 30 -1280 50 {
lab=#net8}
N -1350 80 -1320 80 {
lab=#net6}
N -1350 -20 -1320 -20 {
lab=#net6}
N -1280 10 -1280 30 {
lab=#net8}
N -1280 30 -1170 30 {
lab=#net8}
N -1170 -20 -1170 30 {
lab=#net8}
N -1230 80 -1230 310 {
lab=GND}
N -1280 110 -1280 230 {
lab=#net9}
N -1230 -250 -1100 -250 {lab=VDD}
N -1280 -250 -1280 -170 {lab=VDD}
N -1100 -250 -1100 -20 {lab=VDD}
N -1320 -170 -1320 -110 {lab=#net3}
N -1320 190 -1320 260 {lab=VCtrl}
N -1280 -140 -1280 -50 {lab=#net10}
N -1280 260 -1280 310 {lab=GND}
N -1230 -250 -1230 -20 {lab=VDD}
N -1280 -250 -1230 -250 {lab=VDD}
N -1280 310 -1230 310 {lab=GND}
N -1100 30 -1100 50 {
lab=#net11}
N -1100 80 -1100 310 {lab=GND}
N -1530 -250 -1280 -250 {lab=VDD}
N -1350 30 -1350 80 {lab=#net6}
N -1530 30 -1350 30 {lab=#net6}
N -1350 -20 -1350 30 {lab=#net6}
N -1530 10 -1530 30 {
lab=#net6}
N -1750 -110 -1320 -110 {lab=#net3}
N -1750 190 -1320 190 {lab=VCtrl}
N -730 80 -700 80 {
lab=#net12}
N -730 -20 -700 -20 {
lab=#net12}
N -730 30 -730 80 {
lab=#net12}
N -840 80 -790 80 {
lab=GND}
N -840 -20 -790 -20 {
lab=VDD}
N -840 30 -840 50 {
lab=#net12}
N -910 80 -880 80 {
lab=#net11}
N -910 -20 -880 -20 {
lab=#net11}
N -840 10 -840 30 {
lab=#net12}
N -840 30 -730 30 {
lab=#net12}
N -730 -20 -730 30 {
lab=#net12}
N -910 30 -910 80 {
lab=#net11}
N -790 80 -790 310 {
lab=GND}
N -840 110 -840 230 {
lab=#net13}
N -790 -250 -660 -250 {lab=VDD}
N -840 -250 -840 -170 {lab=VDD}
N -660 -250 -660 -20 {lab=VDD}
N -880 -170 -880 -110 {lab=#net3}
N -880 190 -880 260 {lab=VCtrl}
N -840 -140 -840 -50 {lab=#net14}
N -840 260 -840 310 {lab=GND}
N -790 -250 -790 -20 {lab=VDD}
N -840 -250 -790 -250 {lab=VDD}
N -840 310 -790 310 {lab=GND}
N -660 30 -660 50 {
lab=#net15}
N -660 310 -410 310 {lab=GND}
N -1100 30 -910 30 {lab=#net11}
N -910 -20 -910 30 {
lab=#net11}
N -410 80 -360 80 {
lab=GND}
N -410 -20 -360 -20 {
lab=VDD}
N -480 80 -450 80 {
lab=#net15}
N -480 -20 -450 -20 {
lab=#net15}
N -410 30 -410 50 {
lab=#net16}
N -360 80 -360 310 {
lab=GND}
N -410 110 -410 230 {
lab=#net17}
N -410 -250 -410 -170 {lab=VDD}
N -450 -170 -450 -110 {lab=#net3}
N -450 190 -450 260 {lab=VCtrl}
N -410 -140 -410 -50 {lab=#net18}
N -410 260 -410 310 {lab=GND}
N -360 -250 -360 -20 {lab=VDD}
N -410 -250 -360 -250 {lab=VDD}
N -410 310 -360 310 {lab=GND}
N -660 -250 -410 -250 {lab=VDD}
N -480 30 -480 80 {lab=#net15}
N -660 30 -480 30 {lab=#net15}
N -480 -20 -480 30 {lab=#net15}
N -660 10 -660 30 {
lab=#net15}
N -880 -110 -450 -110 {lab=#net3}
N -880 190 -450 190 {lab=VCtrl}
N -1100 10 -1100 30 {
lab=#net11}
N -1100 310 -840 310 {lab=GND}
N -1230 310 -1100 310 {lab=GND}
N -1320 190 -880 190 {lab=VCtrl}
N -1320 -110 -880 -110 {lab=#net3}
N -1100 -250 -840 -250 {lab=VDD}
N -1530 80 -1530 310 {lab=GND}
N -1660 310 -1530 310 {lab=GND}
N -660 80 -660 310 {lab=GND}
N -790 310 -660 310 {lab=GND}
N -2040 260 -1960 260 {lab=VCtrl}
N -2290 90 -2290 130 {lab=VCtrl}
N -2390 20 -2330 20 {lab=#net19}
N -2290 90 -2150 90 {lab=VCtrl}
N -2290 50 -2290 90 {lab=VCtrl}
N -2290 -70 -2290 -10 {lab=#net20}
N -2290 -150 -2290 -100 {lab=VDD}
N -2290 20 -2210 -70 {lab=VDD}
N -2290 -150 -2210 -70 {lab=VDD}
N -2290 160 -2200 240 {lab=GND}
N -2290 320 -2200 240 {lab=GND}
N -3000 90 -3000 150 {lab=#net21}
N -3000 90 -2770 90 {lab=#net21}
N -3000 30 -3000 90 {lab=#net21}
N -2820 -10 -2650 -10 {lab=up}
N -2650 -10 -2650 70 {lab=up}
N -2650 110 -2650 190 {lab=down}
N -2820 190 -2650 190 {lab=down}
N -2290 290 -2290 320 {lab=GND}
N -2490 290 -2330 290 {lab=#net22}
N -2540 290 -2540 320 {lab=GND}
N -2540 320 -2290 320 {lab=GND}
N -2580 250 -2580 290 {lab=#net22}
N -2580 250 -2540 250 {lab=#net22}
N -2540 250 -2540 260 {lab=#net22}
N -2540 250 -2490 250 {lab=#net22}
N -2490 250 -2490 290 {lab=#net22}
N -2550 -90 -2550 -60 {lab=#net23}
N -2510 -150 -2510 -90 {lab=VDD}
N -2510 -150 -2290 -150 {lab=VDD}
N -2330 -100 -2330 -60 {lab=#net23}
N -2550 -60 -2330 -60 {lab=#net23}
N -1600 990 -1570 990 {
lab=#net24}
N -1600 890 -1570 890 {
lab=#net24}
N -1600 940 -1600 990 {
lab=#net24}
N -1710 990 -1660 990 {
lab=GND}
N -1710 890 -1660 890 {
lab=VDD}
N -1710 940 -1710 960 {
lab=#net24}
N -1780 990 -1750 990 {
lab=delaycheckin}
N -1780 890 -1750 890 {
lab=delaycheckin}
N -1710 920 -1710 940 {
lab=#net24}
N -1710 940 -1600 940 {
lab=#net24}
N -1600 890 -1600 940 {
lab=#net24}
N -1780 940 -1780 990 {
lab=delaycheckin}
N -1660 990 -1660 1220 {
lab=GND}
N -1710 1020 -1710 1140 {
lab=#net25}
N -1660 660 -1530 660 {lab=VDD}
N -1710 660 -1710 740 {lab=VDD}
N -1530 660 -1530 890 {lab=VDD}
N -1750 740 -1750 800 {lab=#net26}
N -1750 1100 -1750 1170 {lab=VCtrl}
N -1920 660 -1920 740 {lab=VDD}
N -1960 740 -1960 800 {lab=#net26}
N -1920 660 -1710 660 {lab=VDD}
N -1920 1220 -1710 1220 {lab=GND}
N -1920 800 -1920 860 {lab=#net26}
N -1960 800 -1920 800 {lab=#net26}
N -1920 770 -1920 800 {lab=#net26}
N -1920 800 -1750 800 {lab=#net26}
N -1920 920 -1920 1140 {lab=#net27}
N -1710 770 -1710 860 {lab=#net28}
N -1710 1170 -1710 1220 {lab=GND}
N -1920 1170 -1920 1220 {lab=GND}
N -1660 660 -1660 890 {lab=VDD}
N -1710 660 -1660 660 {lab=VDD}
N -1710 1220 -1660 1220 {lab=GND}
N -1530 940 -1530 960 {
lab=#net29}
N -1530 1220 -1280 1220 {lab=GND}
N -1960 1100 -1750 1100 {lab=VCtrl}
N -1960 1100 -1960 1170 {lab=VCtrl}
N -1970 940 -1780 940 {lab=delaycheckin}
N -1970 940 -1970 960 {lab=delaycheckin}
N -1780 890 -1780 940 {
lab=delaycheckin}
N -1170 990 -1140 990 {
lab=#net30}
N -1170 890 -1140 890 {
lab=#net30}
N -1170 940 -1170 990 {
lab=#net30}
N -1280 990 -1230 990 {
lab=GND}
N -1280 890 -1230 890 {
lab=VDD}
N -1280 940 -1280 960 {
lab=#net30}
N -1350 990 -1320 990 {
lab=#net29}
N -1350 890 -1320 890 {
lab=#net29}
N -1280 920 -1280 940 {
lab=#net30}
N -1280 940 -1170 940 {
lab=#net30}
N -1170 890 -1170 940 {
lab=#net30}
N -1230 990 -1230 1220 {
lab=GND}
N -1280 1020 -1280 1140 {
lab=#net31}
N -1230 660 -1100 660 {lab=VDD}
N -1280 660 -1280 740 {lab=VDD}
N -1100 660 -1100 890 {lab=VDD}
N -1320 740 -1320 800 {lab=#net26}
N -1320 1100 -1320 1170 {lab=VCtrl}
N -1280 770 -1280 860 {lab=#net32}
N -1280 1170 -1280 1220 {lab=GND}
N -1230 660 -1230 890 {lab=VDD}
N -1280 660 -1230 660 {lab=VDD}
N -1280 1220 -1230 1220 {lab=GND}
N -1100 940 -1100 960 {
lab=#net33}
N -1100 990 -1100 1220 {lab=GND}
N -1530 660 -1280 660 {lab=VDD}
N -1350 940 -1350 990 {lab=#net29}
N -1530 940 -1350 940 {lab=#net29}
N -1350 890 -1350 940 {lab=#net29}
N -1530 920 -1530 940 {
lab=#net29}
N -1750 800 -1320 800 {lab=#net26}
N -1750 1100 -1320 1100 {lab=VCtrl}
N -730 990 -700 990 {
lab=#net34}
N -730 890 -700 890 {
lab=#net34}
N -730 940 -730 990 {
lab=#net34}
N -840 990 -790 990 {
lab=GND}
N -840 890 -790 890 {
lab=VDD}
N -840 940 -840 960 {
lab=#net34}
N -910 990 -880 990 {
lab=#net33}
N -910 890 -880 890 {
lab=#net33}
N -840 920 -840 940 {
lab=#net34}
N -840 940 -730 940 {
lab=#net34}
N -730 890 -730 940 {
lab=#net34}
N -910 940 -910 990 {
lab=#net33}
N -790 990 -790 1220 {
lab=GND}
N -840 1020 -840 1140 {
lab=#net35}
N -790 660 -660 660 {lab=VDD}
N -840 660 -840 740 {lab=VDD}
N -660 660 -660 890 {lab=VDD}
N -880 740 -880 800 {lab=#net26}
N -880 1100 -880 1170 {lab=VCtrl}
N -840 770 -840 860 {lab=#net36}
N -840 1170 -840 1220 {lab=GND}
N -790 660 -790 890 {lab=VDD}
N -840 660 -790 660 {lab=VDD}
N -840 1220 -790 1220 {lab=GND}
N -660 940 -660 960 {
lab=#net37}
N -660 1220 -410 1220 {lab=GND}
N -1100 940 -910 940 {lab=#net33}
N -910 890 -910 940 {
lab=#net33}
N -410 990 -360 990 {
lab=GND}
N -410 890 -360 890 {
lab=VDD}
N -480 990 -450 990 {
lab=#net37}
N -480 890 -450 890 {
lab=#net37}
N -410 940 -410 960 {
lab=#net38}
N -360 990 -360 1220 {
lab=GND}
N -410 1020 -410 1140 {
lab=#net39}
N -410 660 -410 740 {lab=VDD}
N -450 740 -450 800 {lab=#net26}
N -450 1100 -450 1170 {lab=VCtrl}
N -410 770 -410 860 {lab=#net40}
N -410 1170 -410 1220 {lab=GND}
N -360 660 -360 890 {lab=VDD}
N -660 660 -410 660 {lab=VDD}
N -480 940 -480 990 {lab=#net37}
N -660 940 -480 940 {lab=#net37}
N -480 890 -480 940 {lab=#net37}
N -660 920 -660 940 {
lab=#net37}
N -1100 920 -1100 940 {
lab=#net33}
N -1100 1220 -840 1220 {lab=GND}
N -1230 1220 -1100 1220 {lab=GND}
N -1320 1100 -880 1100 {lab=VCtrl}
N -1320 800 -880 800 {lab=#net26}
N -1100 660 -840 660 {lab=VDD}
N -1530 990 -1530 1220 {lab=GND}
N -1660 1220 -1530 1220 {lab=GND}
N -660 990 -660 1220 {lab=GND}
N -790 1220 -660 1220 {lab=GND}
N -2040 1170 -1960 1170 {lab=VCtrl}
N -300 80 -270 80 {
lab=#net16}
N -300 -20 -270 -20 {
lab=#net16}
N -300 30 -300 80 {
lab=#net16}
N -410 30 -300 30 {
lab=#net16}
N -300 -20 -300 30 {
lab=#net16}
N -360 -250 -230 -250 {lab=VDD}
N -230 -250 -230 -20 {lab=VDD}
N -230 30 -230 50 {
lab=#net41}
N -230 10 -230 30 {
lab=#net41}
N -230 80 -230 310 {lab=GND}
N -360 310 -230 310 {lab=GND}
N -410 10 -410 30 {
lab=#net16}
N 170 80 200 80 {
lab=#net42}
N 170 -20 200 -20 {
lab=#net42}
N 170 30 170 80 {
lab=#net42}
N 60 80 110 80 {
lab=GND}
N 60 -20 110 -20 {
lab=VDD}
N 60 30 60 50 {
lab=#net42}
N -10 80 20 80 {
lab=#net41}
N -10 -20 20 -20 {
lab=#net41}
N 60 10 60 30 {
lab=#net42}
N 60 30 170 30 {
lab=#net42}
N 170 -20 170 30 {
lab=#net42}
N -10 30 -10 80 {
lab=#net41}
N 110 80 110 310 {
lab=GND}
N 60 110 60 230 {
lab=#net43}
N 110 -250 240 -250 {lab=VDD}
N 60 -250 60 -170 {lab=VDD}
N 240 -250 240 -20 {lab=VDD}
N 20 -170 20 -110 {lab=#net3}
N 20 190 20 260 {lab=VCtrl}
N 60 -140 60 -50 {lab=#net44}
N 60 260 60 310 {lab=GND}
N 110 -250 110 -20 {lab=VDD}
N 60 -250 110 -250 {lab=VDD}
N 60 310 110 310 {lab=GND}
N 240 30 240 50 {
lab=#net45}
N 240 310 490 310 {lab=GND}
N -10 -20 -10 30 {
lab=#net41}
N 600 80 630 80 {
lab=#net46}
N 600 -20 630 -20 {
lab=#net46}
N 600 30 600 80 {
lab=#net46}
N 490 80 540 80 {
lab=GND}
N 490 -20 540 -20 {
lab=VDD}
N 490 30 490 50 {
lab=#net46}
N 420 80 450 80 {
lab=#net45}
N 420 -20 450 -20 {
lab=#net45}
N 490 10 490 30 {
lab=#net46}
N 490 30 600 30 {
lab=#net46}
N 600 -20 600 30 {
lab=#net46}
N 540 80 540 310 {
lab=GND}
N 490 110 490 230 {
lab=#net47}
N 540 -250 670 -250 {lab=VDD}
N 490 -250 490 -170 {lab=VDD}
N 670 -250 670 -20 {lab=VDD}
N 450 -170 450 -110 {lab=#net3}
N 450 190 450 260 {lab=VCtrl}
N 490 -140 490 -50 {lab=#net48}
N 490 260 490 310 {lab=GND}
N 540 -250 540 -20 {lab=VDD}
N 490 -250 540 -250 {lab=VDD}
N 490 310 540 310 {lab=GND}
N 670 30 670 50 {
lab=#net49}
N 670 80 670 310 {lab=GND}
N 240 -250 490 -250 {lab=VDD}
N 420 30 420 80 {lab=#net45}
N 240 30 420 30 {lab=#net45}
N 420 -20 420 30 {lab=#net45}
N 240 10 240 30 {
lab=#net45}
N 20 -110 450 -110 {lab=#net3}
N 20 190 450 190 {lab=VCtrl}
N 1040 80 1070 80 {
lab=#net50}
N 1040 -20 1070 -20 {
lab=#net50}
N 1040 30 1040 80 {
lab=#net50}
N 930 80 980 80 {
lab=GND}
N 930 -20 980 -20 {
lab=VDD}
N 930 30 930 50 {
lab=#net50}
N 860 80 890 80 {
lab=#net49}
N 860 -20 890 -20 {
lab=#net49}
N 930 10 930 30 {
lab=#net50}
N 930 30 1040 30 {
lab=#net50}
N 1040 -20 1040 30 {
lab=#net50}
N 860 30 860 80 {
lab=#net49}
N 980 80 980 310 {
lab=GND}
N 930 110 930 230 {
lab=#net51}
N 980 -250 1110 -250 {lab=VDD}
N 930 -250 930 -170 {lab=VDD}
N 1110 -250 1110 -20 {lab=VDD}
N 890 -170 890 -110 {lab=#net3}
N 890 190 890 260 {lab=VCtrl}
N 930 -140 930 -50 {lab=#net52}
N 930 260 930 310 {lab=GND}
N 980 -250 980 -20 {lab=VDD}
N 930 -250 980 -250 {lab=VDD}
N 930 310 980 310 {lab=GND}
N 1110 30 1110 50 {
lab=#net53}
N 1110 310 1360 310 {lab=GND}
N 670 30 860 30 {lab=#net49}
N 860 -20 860 30 {
lab=#net49}
N 1360 80 1410 80 {
lab=GND}
N 1360 -20 1410 -20 {
lab=VDD}
N 1290 80 1320 80 {
lab=#net53}
N 1290 -20 1320 -20 {
lab=#net53}
N 1360 30 1360 50 {
lab=#net54}
N 1410 80 1410 310 {
lab=GND}
N 1360 110 1360 230 {
lab=#net55}
N 1360 -250 1360 -170 {lab=VDD}
N 1320 -170 1320 -110 {lab=#net3}
N 1320 190 1320 260 {lab=VCtrl}
N 1360 -140 1360 -50 {lab=#net56}
N 1360 260 1360 310 {lab=GND}
N 1410 -250 1410 -20 {lab=VDD}
N 1360 -250 1410 -250 {lab=VDD}
N 1360 310 1410 310 {lab=GND}
N 1110 -250 1360 -250 {lab=VDD}
N 1290 30 1290 80 {lab=#net53}
N 1110 30 1290 30 {lab=#net53}
N 1290 -20 1290 30 {lab=#net53}
N 1110 10 1110 30 {
lab=#net53}
N 890 -110 1320 -110 {lab=#net3}
N 890 190 1320 190 {lab=VCtrl}
N 670 10 670 30 {
lab=#net49}
N 670 310 930 310 {lab=GND}
N 540 310 670 310 {lab=GND}
N 450 190 890 190 {lab=VCtrl}
N 450 -110 890 -110 {lab=#net3}
N 670 -250 930 -250 {lab=VDD}
N 240 80 240 310 {lab=GND}
N 110 310 240 310 {lab=GND}
N 1110 80 1110 310 {lab=GND}
N 980 310 1110 310 {lab=GND}
N 1470 80 1500 80 {
lab=#net54}
N 1470 -20 1500 -20 {
lab=#net54}
N 1470 30 1470 80 {
lab=#net54}
N 1360 30 1470 30 {
lab=#net54}
N 1470 -20 1470 30 {
lab=#net54}
N 1410 -250 1540 -250 {lab=VDD}
N 1540 -250 1540 -20 {lab=VDD}
N 1540 30 1540 50 {
lab=#net57}
N 1540 10 1540 30 {
lab=#net57}
N 1540 80 1540 310 {lab=GND}
N 1410 310 1540 310 {lab=GND}
N 1360 10 1360 30 {
lab=#net54}
N -230 310 60 310 {lab=GND}
N -230 -250 60 -250 {lab=VDD}
N -230 30 -10 30 {lab=#net41}
N -450 -110 20 -110 {lab=#net3}
N -450 190 20 190 {lab=VCtrl}
N 2000 80 2030 80 {
lab=#net58}
N 2000 -20 2030 -20 {
lab=#net58}
N 2000 30 2000 80 {
lab=#net58}
N 1890 80 1940 80 {
lab=GND}
N 1890 -20 1940 -20 {
lab=VDD}
N 1890 30 1890 50 {
lab=#net58}
N 1820 80 1850 80 {
lab=#net57}
N 1820 -20 1850 -20 {
lab=#net57}
N 1890 10 1890 30 {
lab=#net58}
N 1890 30 2000 30 {
lab=#net58}
N 2000 -20 2000 30 {
lab=#net58}
N 1820 30 1820 80 {
lab=#net57}
N 1940 80 1940 310 {
lab=GND}
N 1890 110 1890 230 {
lab=#net59}
N 1940 -250 2070 -250 {lab=VDD}
N 1890 -250 1890 -170 {lab=VDD}
N 2070 -250 2070 -20 {lab=VDD}
N 1850 -170 1850 -110 {lab=#net3}
N 1850 190 1850 260 {lab=VCtrl}
N 1890 -140 1890 -50 {lab=#net60}
N 1890 260 1890 310 {lab=GND}
N 1940 -250 1940 -20 {lab=VDD}
N 1890 -250 1940 -250 {lab=VDD}
N 1890 310 1940 310 {lab=GND}
N 2070 30 2070 50 {
lab=#net61}
N 2070 310 2320 310 {lab=GND}
N 1820 -20 1820 30 {
lab=#net57}
N 2430 80 2460 80 {
lab=#net62}
N 2430 -20 2460 -20 {
lab=#net62}
N 2430 30 2430 80 {
lab=#net62}
N 2320 80 2370 80 {
lab=GND}
N 2320 -20 2370 -20 {
lab=VDD}
N 2320 30 2320 50 {
lab=#net62}
N 2250 80 2280 80 {
lab=#net61}
N 2250 -20 2280 -20 {
lab=#net61}
N 2320 10 2320 30 {
lab=#net62}
N 2320 30 2430 30 {
lab=#net62}
N 2430 -20 2430 30 {
lab=#net62}
N 2370 80 2370 310 {
lab=GND}
N 2320 110 2320 230 {
lab=#net63}
N 2370 -250 2500 -250 {lab=VDD}
N 2320 -250 2320 -170 {lab=VDD}
N 2500 -250 2500 -20 {lab=VDD}
N 2280 -170 2280 -110 {lab=#net3}
N 2280 190 2280 260 {lab=VCtrl}
N 2320 -140 2320 -50 {lab=#net64}
N 2320 260 2320 310 {lab=GND}
N 2370 -250 2370 -20 {lab=VDD}
N 2320 -250 2370 -250 {lab=VDD}
N 2320 310 2370 310 {lab=GND}
N 2500 30 2500 50 {
lab=#net65}
N 2500 80 2500 310 {lab=GND}
N 2070 -250 2320 -250 {lab=VDD}
N 2250 30 2250 80 {lab=#net61}
N 2070 30 2250 30 {lab=#net61}
N 2250 -20 2250 30 {lab=#net61}
N 2070 10 2070 30 {
lab=#net61}
N 1850 -110 2280 -110 {lab=#net3}
N 1850 190 2280 190 {lab=VCtrl}
N 2870 80 2900 80 {
lab=#net66}
N 2870 -20 2900 -20 {
lab=#net66}
N 2870 30 2870 80 {
lab=#net66}
N 2760 80 2810 80 {
lab=GND}
N 2760 -20 2810 -20 {
lab=VDD}
N 2760 30 2760 50 {
lab=#net66}
N 2690 80 2720 80 {
lab=#net65}
N 2690 -20 2720 -20 {
lab=#net65}
N 2760 10 2760 30 {
lab=#net66}
N 2760 30 2870 30 {
lab=#net66}
N 2870 -20 2870 30 {
lab=#net66}
N 2690 30 2690 80 {
lab=#net65}
N 2810 80 2810 310 {
lab=GND}
N 2760 110 2760 230 {
lab=#net67}
N 2810 -250 2940 -250 {lab=VDD}
N 2760 -250 2760 -170 {lab=VDD}
N 2940 -250 2940 -20 {lab=VDD}
N 2720 -170 2720 -110 {lab=#net3}
N 2720 190 2720 260 {lab=VCtrl}
N 2760 -140 2760 -50 {lab=#net68}
N 2760 260 2760 310 {lab=GND}
N 2810 -250 2810 -20 {lab=VDD}
N 2760 -250 2810 -250 {lab=VDD}
N 2760 310 2810 310 {lab=GND}
N 2940 30 2940 50 {
lab=#net69}
N 2940 310 3190 310 {lab=GND}
N 2500 30 2690 30 {lab=#net65}
N 2690 -20 2690 30 {
lab=#net65}
N 3190 80 3240 80 {
lab=GND}
N 3190 -20 3240 -20 {
lab=VDD}
N 3120 80 3150 80 {
lab=#net69}
N 3120 -20 3150 -20 {
lab=#net69}
N 3190 30 3190 50 {
lab=#net70}
N 3240 80 3240 310 {
lab=GND}
N 3190 110 3190 230 {
lab=#net71}
N 3190 -250 3190 -170 {lab=VDD}
N 3150 -170 3150 -110 {lab=#net3}
N 3150 190 3150 260 {lab=VCtrl}
N 3190 -140 3190 -50 {lab=#net72}
N 3190 260 3190 310 {lab=GND}
N 3240 -250 3240 -20 {lab=VDD}
N 3190 -250 3240 -250 {lab=VDD}
N 3190 310 3240 310 {lab=GND}
N 2940 -250 3190 -250 {lab=VDD}
N 3120 30 3120 80 {lab=#net69}
N 2940 30 3120 30 {lab=#net69}
N 3120 -20 3120 30 {lab=#net69}
N 2940 10 2940 30 {
lab=#net69}
N 2720 -110 3150 -110 {lab=#net3}
N 2720 190 3150 190 {lab=VCtrl}
N 2500 10 2500 30 {
lab=#net65}
N 2500 310 2760 310 {lab=GND}
N 2370 310 2500 310 {lab=GND}
N 2280 190 2720 190 {lab=VCtrl}
N 2280 -110 2720 -110 {lab=#net3}
N 2500 -250 2760 -250 {lab=VDD}
N 2070 80 2070 310 {lab=GND}
N 1940 310 2070 310 {lab=GND}
N 2940 80 2940 310 {lab=GND}
N 2810 310 2940 310 {lab=GND}
N 3300 80 3330 80 {
lab=#net70}
N 3300 -20 3330 -20 {
lab=#net70}
N 3300 30 3300 80 {
lab=#net70}
N 3190 30 3300 30 {
lab=#net70}
N 3300 -20 3300 30 {
lab=#net70}
N 3240 -250 3370 -250 {lab=VDD}
N 3370 -250 3370 -20 {lab=VDD}
N 3370 30 3370 50 {
lab=#net73}
N 3370 10 3370 30 {
lab=#net73}
N 3370 80 3370 310 {lab=GND}
N 3240 310 3370 310 {lab=GND}
N 3190 10 3190 30 {
lab=#net70}
N 1540 310 1890 310 {lab=GND}
N 1540 -250 1890 -250 {lab=VDD}
N 1540 30 1820 30 {lab=#net57}
N 1320 -110 1850 -110 {lab=#net3}
N 1320 190 1850 190 {lab=VCtrl}
N 3820 80 3850 80 {
lab=#net74}
N 3820 -20 3850 -20 {
lab=#net74}
N 3820 30 3820 80 {
lab=#net74}
N 3710 80 3760 80 {
lab=GND}
N 3710 -20 3760 -20 {
lab=VDD}
N 3710 30 3710 50 {
lab=#net74}
N 3640 80 3670 80 {
lab=#net73}
N 3640 -20 3670 -20 {
lab=#net73}
N 3710 10 3710 30 {
lab=#net74}
N 3710 30 3820 30 {
lab=#net74}
N 3820 -20 3820 30 {
lab=#net74}
N 3640 30 3640 80 {
lab=#net73}
N 3760 80 3760 310 {
lab=GND}
N 3710 110 3710 230 {
lab=#net75}
N 3760 -250 3890 -250 {lab=VDD}
N 3710 -250 3710 -170 {lab=VDD}
N 3890 -250 3890 -20 {lab=VDD}
N 3670 -170 3670 -110 {lab=#net3}
N 3670 190 3670 260 {lab=VCtrl}
N 3710 -140 3710 -50 {lab=#net76}
N 3710 260 3710 310 {lab=GND}
N 3760 -250 3760 -20 {lab=VDD}
N 3710 -250 3760 -250 {lab=VDD}
N 3710 310 3760 310 {lab=GND}
N 3890 30 3890 50 {
lab=#net77}
N 3890 310 4140 310 {lab=GND}
N 3640 -20 3640 30 {
lab=#net73}
N 4250 80 4280 80 {
lab=#net78}
N 4250 -20 4280 -20 {
lab=#net78}
N 4250 30 4250 80 {
lab=#net78}
N 4140 80 4190 80 {
lab=GND}
N 4140 -20 4190 -20 {
lab=VDD}
N 4140 30 4140 50 {
lab=#net78}
N 4070 80 4100 80 {
lab=#net77}
N 4070 -20 4100 -20 {
lab=#net77}
N 4140 10 4140 30 {
lab=#net78}
N 4140 30 4250 30 {
lab=#net78}
N 4250 -20 4250 30 {
lab=#net78}
N 4190 80 4190 310 {
lab=GND}
N 4140 110 4140 230 {
lab=#net79}
N 4190 -250 4320 -250 {lab=VDD}
N 4140 -250 4140 -170 {lab=VDD}
N 4320 -250 4320 -20 {lab=VDD}
N 4100 -170 4100 -110 {lab=#net3}
N 4100 190 4100 260 {lab=VCtrl}
N 4140 -140 4140 -50 {lab=#net80}
N 4140 260 4140 310 {lab=GND}
N 4190 -250 4190 -20 {lab=VDD}
N 4140 -250 4190 -250 {lab=VDD}
N 4140 310 4190 310 {lab=GND}
N 4320 30 4320 50 {
lab=#net81}
N 4320 80 4320 310 {lab=GND}
N 3890 -250 4140 -250 {lab=VDD}
N 4070 30 4070 80 {lab=#net77}
N 3890 30 4070 30 {lab=#net77}
N 4070 -20 4070 30 {lab=#net77}
N 3890 10 3890 30 {
lab=#net77}
N 3670 -110 4100 -110 {lab=#net3}
N 3670 190 4100 190 {lab=VCtrl}
N 4690 80 4720 80 {
lab=#net82}
N 4690 -20 4720 -20 {
lab=#net82}
N 4690 30 4690 80 {
lab=#net82}
N 4580 80 4630 80 {
lab=GND}
N 4580 -20 4630 -20 {
lab=VDD}
N 4580 30 4580 50 {
lab=#net82}
N 4510 80 4540 80 {
lab=#net81}
N 4510 -20 4540 -20 {
lab=#net81}
N 4580 10 4580 30 {
lab=#net82}
N 4580 30 4690 30 {
lab=#net82}
N 4690 -20 4690 30 {
lab=#net82}
N 4510 30 4510 80 {
lab=#net81}
N 4630 80 4630 310 {
lab=GND}
N 4580 110 4580 230 {
lab=#net83}
N 4630 -250 4760 -250 {lab=VDD}
N 4580 -250 4580 -170 {lab=VDD}
N 4760 -250 4760 -20 {lab=VDD}
N 4540 -170 4540 -110 {lab=#net3}
N 4540 190 4540 260 {lab=VCtrl}
N 4580 -140 4580 -50 {lab=#net84}
N 4580 260 4580 310 {lab=GND}
N 4630 -250 4630 -20 {lab=VDD}
N 4580 -250 4630 -250 {lab=VDD}
N 4580 310 4630 310 {lab=GND}
N 4760 30 4760 50 {
lab=#net85}
N 4760 310 5010 310 {lab=GND}
N 4320 30 4510 30 {lab=#net81}
N 4510 -20 4510 30 {
lab=#net81}
N 5010 80 5060 80 {
lab=GND}
N 5010 -20 5060 -20 {
lab=VDD}
N 4940 80 4970 80 {
lab=#net85}
N 4940 -20 4970 -20 {
lab=#net85}
N 5010 30 5010 50 {
lab=#net86}
N 5060 80 5060 310 {
lab=GND}
N 5010 110 5010 230 {
lab=#net87}
N 5010 -250 5010 -170 {lab=VDD}
N 4970 -170 4970 -110 {lab=#net3}
N 4970 190 4970 260 {lab=VCtrl}
N 5010 -140 5010 -50 {lab=#net88}
N 5010 260 5010 310 {lab=GND}
N 5060 -250 5060 -20 {lab=VDD}
N 5010 -250 5060 -250 {lab=VDD}
N 5010 310 5060 310 {lab=GND}
N 4760 -250 5010 -250 {lab=VDD}
N 4940 30 4940 80 {lab=#net85}
N 4760 30 4940 30 {lab=#net85}
N 4940 -20 4940 30 {lab=#net85}
N 4760 10 4760 30 {
lab=#net85}
N 4540 -110 4970 -110 {lab=#net3}
N 4540 190 4970 190 {lab=VCtrl}
N 4320 10 4320 30 {
lab=#net81}
N 4320 310 4580 310 {lab=GND}
N 4190 310 4320 310 {lab=GND}
N 4100 190 4540 190 {lab=VCtrl}
N 4100 -110 4540 -110 {lab=#net3}
N 4320 -250 4580 -250 {lab=VDD}
N 3890 80 3890 310 {lab=GND}
N 3760 310 3890 310 {lab=GND}
N 4760 80 4760 310 {lab=GND}
N 4630 310 4760 310 {lab=GND}
N 5120 80 5150 80 {
lab=#net86}
N 5120 -20 5150 -20 {
lab=#net86}
N 5120 30 5120 80 {
lab=#net86}
N 5010 30 5120 30 {
lab=#net86}
N 5120 -20 5120 30 {
lab=#net86}
N 5060 -250 5190 -250 {lab=VDD}
N 5190 -250 5190 -20 {lab=VDD}
N 5190 30 5190 50 {
lab=#net89}
N 5190 10 5190 30 {
lab=#net89}
N 5190 80 5190 310 {lab=GND}
N 5060 310 5190 310 {lab=GND}
N 5010 10 5010 30 {
lab=#net86}
N 3370 310 3710 310 {lab=GND}
N 3370 -250 3710 -250 {lab=VDD}
N 3370 30 3640 30 {lab=#net73}
N 3150 -110 3670 -110 {lab=#net3}
N 3150 190 3670 190 {lab=VCtrl}
N 5640 80 5670 80 {
lab=#net90}
N 5640 -20 5670 -20 {
lab=#net90}
N 5640 30 5640 80 {
lab=#net90}
N 5530 80 5580 80 {
lab=GND}
N 5530 -20 5580 -20 {
lab=VDD}
N 5530 30 5530 50 {
lab=#net90}
N 5460 80 5490 80 {
lab=#net89}
N 5460 -20 5490 -20 {
lab=#net89}
N 5530 10 5530 30 {
lab=#net90}
N 5530 30 5640 30 {
lab=#net90}
N 5640 -20 5640 30 {
lab=#net90}
N 5460 30 5460 80 {
lab=#net89}
N 5580 80 5580 310 {
lab=GND}
N 5530 110 5530 230 {
lab=#net91}
N 5580 -250 5710 -250 {lab=VDD}
N 5530 -250 5530 -170 {lab=VDD}
N 5710 -250 5710 -20 {lab=VDD}
N 5490 -170 5490 -110 {lab=#net3}
N 5490 190 5490 260 {lab=VCtrl}
N 5530 -140 5530 -50 {lab=#net92}
N 5530 260 5530 310 {lab=GND}
N 5580 -250 5580 -20 {lab=VDD}
N 5530 -250 5580 -250 {lab=VDD}
N 5530 310 5580 310 {lab=GND}
N 5710 30 5710 50 {
lab=#net93}
N 5710 310 5960 310 {lab=GND}
N 5460 -20 5460 30 {
lab=#net89}
N 6070 80 6100 80 {
lab=#net94}
N 6070 -20 6100 -20 {
lab=#net94}
N 6070 30 6070 80 {
lab=#net94}
N 5960 80 6010 80 {
lab=GND}
N 5960 -20 6010 -20 {
lab=VDD}
N 5960 30 5960 50 {
lab=#net94}
N 5890 80 5920 80 {
lab=#net93}
N 5890 -20 5920 -20 {
lab=#net93}
N 5960 10 5960 30 {
lab=#net94}
N 5960 30 6070 30 {
lab=#net94}
N 6070 -20 6070 30 {
lab=#net94}
N 6010 80 6010 310 {
lab=GND}
N 5960 110 5960 230 {
lab=#net95}
N 6010 -250 6140 -250 {lab=VDD}
N 5960 -250 5960 -170 {lab=VDD}
N 6140 -250 6140 -20 {lab=VDD}
N 5920 -170 5920 -110 {lab=#net3}
N 5920 190 5920 260 {lab=VCtrl}
N 5960 -140 5960 -50 {lab=#net96}
N 5960 260 5960 310 {lab=GND}
N 6010 -250 6010 -20 {lab=VDD}
N 5960 -250 6010 -250 {lab=VDD}
N 5960 310 6010 310 {lab=GND}
N 6140 30 6140 50 {
lab=#net97}
N 6140 80 6140 310 {lab=GND}
N 5710 -250 5960 -250 {lab=VDD}
N 5890 30 5890 80 {lab=#net93}
N 5710 30 5890 30 {lab=#net93}
N 5890 -20 5890 30 {lab=#net93}
N 5710 10 5710 30 {
lab=#net93}
N 5490 -110 5920 -110 {lab=#net3}
N 5490 190 5920 190 {lab=VCtrl}
N 6510 80 6540 80 {
lab=#net98}
N 6510 -20 6540 -20 {
lab=#net98}
N 6510 30 6510 80 {
lab=#net98}
N 6400 80 6450 80 {
lab=GND}
N 6400 -20 6450 -20 {
lab=VDD}
N 6400 30 6400 50 {
lab=#net98}
N 6330 80 6360 80 {
lab=#net97}
N 6330 -20 6360 -20 {
lab=#net97}
N 6400 10 6400 30 {
lab=#net98}
N 6400 30 6510 30 {
lab=#net98}
N 6510 -20 6510 30 {
lab=#net98}
N 6330 30 6330 80 {
lab=#net97}
N 6450 80 6450 310 {
lab=GND}
N 6400 110 6400 230 {
lab=#net99}
N 6450 -250 6580 -250 {lab=VDD}
N 6400 -250 6400 -170 {lab=VDD}
N 6580 -250 6580 -20 {lab=VDD}
N 6360 -170 6360 -110 {lab=#net3}
N 6360 190 6360 260 {lab=VCtrl}
N 6400 -140 6400 -50 {lab=#net100}
N 6400 260 6400 310 {lab=GND}
N 6450 -250 6450 -20 {lab=VDD}
N 6400 -250 6450 -250 {lab=VDD}
N 6400 310 6450 310 {lab=GND}
N 6580 30 6580 50 {
lab=#net101}
N 6580 310 6830 310 {lab=GND}
N 6140 30 6330 30 {lab=#net97}
N 6330 -20 6330 30 {
lab=#net97}
N 6830 80 6880 80 {
lab=GND}
N 6830 -20 6880 -20 {
lab=VDD}
N 6760 80 6790 80 {
lab=#net101}
N 6760 -20 6790 -20 {
lab=#net101}
N 6830 30 6830 50 {
lab=#net102}
N 6880 80 6880 310 {
lab=GND}
N 6830 110 6830 230 {
lab=#net103}
N 6830 -250 6830 -170 {lab=VDD}
N 6790 -170 6790 -110 {lab=#net3}
N 6790 190 6790 260 {lab=VCtrl}
N 6830 -140 6830 -50 {lab=#net104}
N 6830 260 6830 310 {lab=GND}
N 6880 -250 6880 -20 {lab=VDD}
N 6830 -250 6880 -250 {lab=VDD}
N 6830 310 6880 310 {lab=GND}
N 6580 -250 6830 -250 {lab=VDD}
N 6760 30 6760 80 {lab=#net101}
N 6580 30 6760 30 {lab=#net101}
N 6760 -20 6760 30 {lab=#net101}
N 6580 10 6580 30 {
lab=#net101}
N 6360 -110 6790 -110 {lab=#net3}
N 6360 190 6790 190 {lab=VCtrl}
N 6140 10 6140 30 {
lab=#net97}
N 6140 310 6400 310 {lab=GND}
N 6010 310 6140 310 {lab=GND}
N 5920 190 6360 190 {lab=VCtrl}
N 5920 -110 6360 -110 {lab=#net3}
N 6140 -250 6400 -250 {lab=VDD}
N 5710 80 5710 310 {lab=GND}
N 5580 310 5710 310 {lab=GND}
N 6580 80 6580 310 {lab=GND}
N 6450 310 6580 310 {lab=GND}
N 6940 80 6970 80 {
lab=#net102}
N 6940 -20 6970 -20 {
lab=#net102}
N 6940 30 6940 80 {
lab=#net102}
N 6830 30 6940 30 {
lab=#net102}
N 6940 -20 6940 30 {
lab=#net102}
N 6880 -250 7010 -250 {lab=VDD}
N 7010 -250 7010 -20 {lab=VDD}
N 7010 30 7010 50 {
lab=#net105}
N 7010 10 7010 30 {
lab=#net105}
N 7010 80 7010 310 {lab=GND}
N 6880 310 7010 310 {lab=GND}
N 6830 10 6830 30 {
lab=#net102}
N 5190 310 5530 310 {lab=GND}
N 5190 -250 5530 -250 {lab=VDD}
N 5190 30 5460 30 {lab=#net89}
N 4970 -110 5490 -110 {lab=#net3}
N 4970 190 5490 190 {lab=VCtrl}
N 7440 80 7470 80 {
lab=#net106}
N 7440 -20 7470 -20 {
lab=#net106}
N 7440 30 7440 80 {
lab=#net106}
N 7330 80 7380 80 {
lab=GND}
N 7330 -20 7380 -20 {
lab=VDD}
N 7330 30 7330 50 {
lab=#net106}
N 7260 80 7290 80 {
lab=#net105}
N 7260 -20 7290 -20 {
lab=#net105}
N 7330 10 7330 30 {
lab=#net106}
N 7330 30 7440 30 {
lab=#net106}
N 7440 -20 7440 30 {
lab=#net106}
N 7260 30 7260 80 {
lab=#net105}
N 7380 80 7380 310 {
lab=GND}
N 7330 110 7330 230 {
lab=#net107}
N 7380 -250 7510 -250 {lab=VDD}
N 7330 -250 7330 -170 {lab=VDD}
N 7510 -250 7510 -20 {lab=VDD}
N 7290 -170 7290 -110 {lab=#net3}
N 7290 190 7290 260 {lab=VCtrl}
N 7330 -140 7330 -50 {lab=#net108}
N 7330 260 7330 310 {lab=GND}
N 7380 -250 7380 -20 {lab=VDD}
N 7330 -250 7380 -250 {lab=VDD}
N 7330 310 7380 310 {lab=GND}
N 7510 30 7510 50 {
lab=#net109}
N 7510 310 7760 310 {lab=GND}
N 7260 -20 7260 30 {
lab=#net105}
N 7870 80 7900 80 {
lab=#net110}
N 7870 -20 7900 -20 {
lab=#net110}
N 7870 30 7870 80 {
lab=#net110}
N 7760 80 7810 80 {
lab=GND}
N 7760 -20 7810 -20 {
lab=VDD}
N 7760 30 7760 50 {
lab=#net110}
N 7690 80 7720 80 {
lab=#net109}
N 7690 -20 7720 -20 {
lab=#net109}
N 7760 10 7760 30 {
lab=#net110}
N 7760 30 7870 30 {
lab=#net110}
N 7870 -20 7870 30 {
lab=#net110}
N 7810 80 7810 310 {
lab=GND}
N 7760 110 7760 230 {
lab=#net111}
N 7810 -250 7940 -250 {lab=VDD}
N 7760 -250 7760 -170 {lab=VDD}
N 7940 -250 7940 -20 {lab=VDD}
N 7720 -170 7720 -110 {lab=#net3}
N 7720 190 7720 260 {lab=VCtrl}
N 7760 -140 7760 -50 {lab=#net112}
N 7760 260 7760 310 {lab=GND}
N 7810 -250 7810 -20 {lab=VDD}
N 7760 -250 7810 -250 {lab=VDD}
N 7760 310 7810 310 {lab=GND}
N 7940 30 7940 50 {
lab=#net113}
N 7940 80 7940 310 {lab=GND}
N 7510 -250 7760 -250 {lab=VDD}
N 7690 30 7690 80 {lab=#net109}
N 7510 30 7690 30 {lab=#net109}
N 7690 -20 7690 30 {lab=#net109}
N 7510 10 7510 30 {
lab=#net109}
N 7290 -110 7720 -110 {lab=#net3}
N 7290 190 7720 190 {lab=VCtrl}
N 8310 80 8340 80 {
lab=#net114}
N 8310 -20 8340 -20 {
lab=#net114}
N 8310 30 8310 80 {
lab=#net114}
N 8200 80 8250 80 {
lab=GND}
N 8200 -20 8250 -20 {
lab=VDD}
N 8200 30 8200 50 {
lab=#net114}
N 8130 80 8160 80 {
lab=#net113}
N 8130 -20 8160 -20 {
lab=#net113}
N 8200 10 8200 30 {
lab=#net114}
N 8200 30 8310 30 {
lab=#net114}
N 8310 -20 8310 30 {
lab=#net114}
N 8130 30 8130 80 {
lab=#net113}
N 8250 80 8250 310 {
lab=GND}
N 8200 110 8200 230 {
lab=#net115}
N 8250 -250 8380 -250 {lab=VDD}
N 8200 -250 8200 -170 {lab=VDD}
N 8380 -250 8380 -20 {lab=VDD}
N 8160 -170 8160 -110 {lab=#net3}
N 8160 190 8160 260 {lab=VCtrl}
N 8200 -140 8200 -50 {lab=#net116}
N 8200 260 8200 310 {lab=GND}
N 8250 -250 8250 -20 {lab=VDD}
N 8200 -250 8250 -250 {lab=VDD}
N 8200 310 8250 310 {lab=GND}
N 8380 30 8380 50 {
lab=#net117}
N 8380 310 8630 310 {lab=GND}
N 7940 30 8130 30 {lab=#net113}
N 8130 -20 8130 30 {
lab=#net113}
N 8630 80 8680 80 {
lab=GND}
N 8630 -20 8680 -20 {
lab=VDD}
N 8560 80 8590 80 {
lab=#net117}
N 8560 -20 8590 -20 {
lab=#net117}
N 8630 30 8630 50 {
lab=#net118}
N 8680 80 8680 310 {
lab=GND}
N 8630 110 8630 230 {
lab=#net119}
N 8630 -250 8630 -170 {lab=VDD}
N 8590 -170 8590 -110 {lab=#net3}
N 8590 190 8590 260 {lab=VCtrl}
N 8630 -140 8630 -50 {lab=#net120}
N 8630 260 8630 310 {lab=GND}
N 8680 -250 8680 -20 {lab=VDD}
N 8630 -250 8680 -250 {lab=VDD}
N 8630 310 8680 310 {lab=GND}
N 8380 -250 8630 -250 {lab=VDD}
N 8560 30 8560 80 {lab=#net117}
N 8380 30 8560 30 {lab=#net117}
N 8560 -20 8560 30 {lab=#net117}
N 8380 10 8380 30 {
lab=#net117}
N 8160 -110 8590 -110 {lab=#net3}
N 8160 190 8590 190 {lab=VCtrl}
N 7940 10 7940 30 {
lab=#net113}
N 7940 310 8200 310 {lab=GND}
N 7810 310 7940 310 {lab=GND}
N 7720 190 8160 190 {lab=VCtrl}
N 7720 -110 8160 -110 {lab=#net3}
N 7940 -250 8200 -250 {lab=VDD}
N 7510 80 7510 310 {lab=GND}
N 7380 310 7510 310 {lab=GND}
N 8380 80 8380 310 {lab=GND}
N 8250 310 8380 310 {lab=GND}
N 8740 80 8770 80 {
lab=#net118}
N 8740 -20 8770 -20 {
lab=#net118}
N 8740 30 8740 80 {
lab=#net118}
N 8630 30 8740 30 {
lab=#net118}
N 8740 -20 8740 30 {
lab=#net118}
N 8680 -250 8810 -250 {lab=VDD}
N 8810 -250 8810 -20 {lab=VDD}
N 8810 30 8810 50 {
lab=#net121}
N 8810 10 8810 30 {
lab=#net121}
N 8810 80 8810 310 {lab=GND}
N 8680 310 8810 310 {lab=GND}
N 8630 10 8630 30 {
lab=#net118}
N 7010 310 7330 310 {lab=GND}
N 7010 -250 7330 -250 {lab=VDD}
N 7010 30 7260 30 {lab=#net105}
N 6790 -110 7290 -110 {lab=#net3}
N 6790 190 7290 190 {lab=VCtrl}
N 9200 80 9230 80 {
lab=#net122}
N 9200 -20 9230 -20 {
lab=#net122}
N 9200 30 9200 80 {
lab=#net122}
N 9090 80 9140 80 {
lab=GND}
N 9090 -20 9140 -20 {
lab=VDD}
N 9090 30 9090 50 {
lab=#net122}
N 9020 80 9050 80 {
lab=#net121}
N 9020 -20 9050 -20 {
lab=#net121}
N 9090 10 9090 30 {
lab=#net122}
N 9090 30 9200 30 {
lab=#net122}
N 9200 -20 9200 30 {
lab=#net122}
N 9020 30 9020 80 {
lab=#net121}
N 9140 80 9140 310 {
lab=GND}
N 9090 110 9090 230 {
lab=#net123}
N 9140 -250 9270 -250 {lab=VDD}
N 9090 -250 9090 -170 {lab=VDD}
N 9270 -250 9270 -20 {lab=VDD}
N 9050 -170 9050 -110 {lab=#net3}
N 9050 190 9050 260 {lab=VCtrl}
N 9090 -140 9090 -50 {lab=#net124}
N 9090 260 9090 310 {lab=GND}
N 9140 -250 9140 -20 {lab=VDD}
N 9090 -250 9140 -250 {lab=VDD}
N 9090 310 9140 310 {lab=GND}
N 9270 30 9270 50 {
lab=#net125}
N 9270 310 9520 310 {lab=GND}
N 9020 -20 9020 30 {
lab=#net121}
N 9630 80 9660 80 {
lab=#net126}
N 9630 -20 9660 -20 {
lab=#net126}
N 9630 30 9630 80 {
lab=#net126}
N 9520 80 9570 80 {
lab=GND}
N 9520 -20 9570 -20 {
lab=VDD}
N 9520 30 9520 50 {
lab=#net126}
N 9450 80 9480 80 {
lab=#net125}
N 9450 -20 9480 -20 {
lab=#net125}
N 9520 10 9520 30 {
lab=#net126}
N 9520 30 9630 30 {
lab=#net126}
N 9630 -20 9630 30 {
lab=#net126}
N 9570 80 9570 310 {
lab=GND}
N 9520 110 9520 230 {
lab=#net127}
N 9570 -250 9700 -250 {lab=VDD}
N 9520 -250 9520 -170 {lab=VDD}
N 9700 -250 9700 -20 {lab=VDD}
N 9480 -170 9480 -110 {lab=#net3}
N 9480 190 9480 260 {lab=VCtrl}
N 9520 -140 9520 -50 {lab=#net128}
N 9520 260 9520 310 {lab=GND}
N 9570 -250 9570 -20 {lab=VDD}
N 9520 -250 9570 -250 {lab=VDD}
N 9520 310 9570 310 {lab=GND}
N 9700 30 9700 50 {
lab=#net129}
N 9700 80 9700 310 {lab=GND}
N 9270 -250 9520 -250 {lab=VDD}
N 9450 30 9450 80 {lab=#net125}
N 9270 30 9450 30 {lab=#net125}
N 9450 -20 9450 30 {lab=#net125}
N 9270 10 9270 30 {
lab=#net125}
N 9050 -110 9480 -110 {lab=#net3}
N 9050 190 9480 190 {lab=VCtrl}
N 10070 80 10100 80 {
lab=#net130}
N 10070 -20 10100 -20 {
lab=#net130}
N 10070 30 10070 80 {
lab=#net130}
N 9960 80 10010 80 {
lab=GND}
N 9960 -20 10010 -20 {
lab=VDD}
N 9960 30 9960 50 {
lab=#net130}
N 9890 80 9920 80 {
lab=#net129}
N 9890 -20 9920 -20 {
lab=#net129}
N 9960 10 9960 30 {
lab=#net130}
N 9960 30 10070 30 {
lab=#net130}
N 10070 -20 10070 30 {
lab=#net130}
N 9890 30 9890 80 {
lab=#net129}
N 10010 80 10010 310 {
lab=GND}
N 9960 110 9960 230 {
lab=#net131}
N 10010 -250 10140 -250 {lab=VDD}
N 9960 -250 9960 -170 {lab=VDD}
N 10140 -250 10140 -20 {lab=VDD}
N 9920 -170 9920 -110 {lab=#net3}
N 9920 190 9920 260 {lab=VCtrl}
N 9960 -140 9960 -50 {lab=#net132}
N 9960 260 9960 310 {lab=GND}
N 10010 -250 10010 -20 {lab=VDD}
N 9960 -250 10010 -250 {lab=VDD}
N 9960 310 10010 310 {lab=GND}
N 10140 30 10140 50 {
lab=#net133}
N 10140 310 10390 310 {lab=GND}
N 9700 30 9890 30 {lab=#net129}
N 9890 -20 9890 30 {
lab=#net129}
N 10390 80 10440 80 {
lab=GND}
N 10390 -20 10440 -20 {
lab=VDD}
N 10320 80 10350 80 {
lab=#net133}
N 10320 -20 10350 -20 {
lab=#net133}
N 10390 30 10390 50 {
lab=#net134}
N 10440 80 10440 310 {
lab=GND}
N 10390 110 10390 230 {
lab=#net135}
N 10390 -250 10390 -170 {lab=VDD}
N 10350 -170 10350 -110 {lab=#net3}
N 10350 190 10350 260 {lab=VCtrl}
N 10390 -140 10390 -50 {lab=#net136}
N 10390 260 10390 310 {lab=GND}
N 10440 -250 10440 -20 {lab=VDD}
N 10390 -250 10440 -250 {lab=VDD}
N 10390 310 10440 310 {lab=GND}
N 10140 -250 10390 -250 {lab=VDD}
N 10320 30 10320 80 {lab=#net133}
N 10140 30 10320 30 {lab=#net133}
N 10320 -20 10320 30 {lab=#net133}
N 10140 10 10140 30 {
lab=#net133}
N 9920 -110 10350 -110 {lab=#net3}
N 9920 190 10350 190 {lab=VCtrl}
N 9700 10 9700 30 {
lab=#net129}
N 9700 310 9960 310 {lab=GND}
N 9570 310 9700 310 {lab=GND}
N 9480 190 9920 190 {lab=VCtrl}
N 9480 -110 9920 -110 {lab=#net3}
N 9700 -250 9960 -250 {lab=VDD}
N 9270 80 9270 310 {lab=GND}
N 9140 310 9270 310 {lab=GND}
N 10140 80 10140 310 {lab=GND}
N 10010 310 10140 310 {lab=GND}
N 10500 80 10530 80 {
lab=#net134}
N 10500 -20 10530 -20 {
lab=#net134}
N 10500 30 10500 80 {
lab=#net134}
N 10390 30 10500 30 {
lab=#net134}
N 10500 -20 10500 30 {
lab=#net134}
N 10440 -250 10570 -250 {lab=VDD}
N 10570 -250 10570 -20 {lab=VDD}
N 10570 30 10570 50 {
lab=#net137}
N 10570 10 10570 30 {
lab=#net137}
N 10570 80 10570 310 {lab=GND}
N 10440 310 10570 310 {lab=GND}
N 10390 10 10390 30 {
lab=#net134}
N 8810 310 9090 310 {lab=GND}
N 8810 -250 9090 -250 {lab=VDD}
N 8810 30 9020 30 {lab=#net121}
N 8590 -110 9050 -110 {lab=#net3}
N 8590 190 9050 190 {lab=VCtrl}
N 10950 80 10980 80 {
lab=#net138}
N 10950 -20 10980 -20 {
lab=#net138}
N 10950 30 10950 80 {
lab=#net138}
N 10840 80 10890 80 {
lab=GND}
N 10840 -20 10890 -20 {
lab=VDD}
N 10840 30 10840 50 {
lab=#net138}
N 10770 80 10800 80 {
lab=#net137}
N 10770 -20 10800 -20 {
lab=#net137}
N 10840 10 10840 30 {
lab=#net138}
N 10840 30 10950 30 {
lab=#net138}
N 10950 -20 10950 30 {
lab=#net138}
N 10770 30 10770 80 {
lab=#net137}
N 10890 80 10890 310 {
lab=GND}
N 10840 110 10840 230 {
lab=#net139}
N 10890 -250 11020 -250 {lab=VDD}
N 10840 -250 10840 -170 {lab=VDD}
N 11020 -250 11020 -20 {lab=VDD}
N 10800 -170 10800 -110 {lab=#net3}
N 10800 190 10800 260 {lab=VCtrl}
N 10840 -140 10840 -50 {lab=#net140}
N 10840 260 10840 310 {lab=GND}
N 10890 -250 10890 -20 {lab=VDD}
N 10840 -250 10890 -250 {lab=VDD}
N 10840 310 10890 310 {lab=GND}
N 11020 30 11020 50 {
lab=#net141}
N 11020 310 11270 310 {lab=GND}
N 10770 -20 10770 30 {
lab=#net137}
N 11380 80 11410 80 {
lab=#net142}
N 11380 -20 11410 -20 {
lab=#net142}
N 11380 30 11380 80 {
lab=#net142}
N 11270 80 11320 80 {
lab=GND}
N 11270 -20 11320 -20 {
lab=VDD}
N 11270 30 11270 50 {
lab=#net142}
N 11200 80 11230 80 {
lab=#net141}
N 11200 -20 11230 -20 {
lab=#net141}
N 11270 10 11270 30 {
lab=#net142}
N 11270 30 11380 30 {
lab=#net142}
N 11380 -20 11380 30 {
lab=#net142}
N 11320 80 11320 310 {
lab=GND}
N 11270 110 11270 230 {
lab=#net143}
N 11320 -250 11450 -250 {lab=VDD}
N 11270 -250 11270 -170 {lab=VDD}
N 11450 -250 11450 -20 {lab=VDD}
N 11230 -170 11230 -110 {lab=#net3}
N 11230 190 11230 260 {lab=VCtrl}
N 11270 -140 11270 -50 {lab=#net144}
N 11270 260 11270 310 {lab=GND}
N 11320 -250 11320 -20 {lab=VDD}
N 11270 -250 11320 -250 {lab=VDD}
N 11270 310 11320 310 {lab=GND}
N 11450 30 11450 50 {
lab=#net145}
N 11450 80 11450 310 {lab=GND}
N 11020 -250 11270 -250 {lab=VDD}
N 11200 30 11200 80 {lab=#net141}
N 11020 30 11200 30 {lab=#net141}
N 11200 -20 11200 30 {lab=#net141}
N 11020 10 11020 30 {
lab=#net141}
N 10800 -110 11230 -110 {lab=#net3}
N 10800 190 11230 190 {lab=VCtrl}
N 11820 80 11850 80 {
lab=#net146}
N 11820 -20 11850 -20 {
lab=#net146}
N 11820 30 11820 80 {
lab=#net146}
N 11710 80 11760 80 {
lab=GND}
N 11710 -20 11760 -20 {
lab=VDD}
N 11710 30 11710 50 {
lab=#net146}
N 11640 80 11670 80 {
lab=#net145}
N 11640 -20 11670 -20 {
lab=#net145}
N 11710 10 11710 30 {
lab=#net146}
N 11710 30 11820 30 {
lab=#net146}
N 11820 -20 11820 30 {
lab=#net146}
N 11640 30 11640 80 {
lab=#net145}
N 11760 80 11760 310 {
lab=GND}
N 11710 110 11710 230 {
lab=#net147}
N 11760 -250 11890 -250 {lab=VDD}
N 11710 -250 11710 -170 {lab=VDD}
N 11890 -250 11890 -20 {lab=VDD}
N 11670 -170 11670 -110 {lab=#net3}
N 11670 190 11670 260 {lab=VCtrl}
N 11710 -140 11710 -50 {lab=#net148}
N 11710 260 11710 310 {lab=GND}
N 11760 -250 11760 -20 {lab=VDD}
N 11710 -250 11760 -250 {lab=VDD}
N 11710 310 11760 310 {lab=GND}
N 11890 30 11890 50 {
lab=#net149}
N 11890 310 12140 310 {lab=GND}
N 11450 30 11640 30 {lab=#net145}
N 11640 -20 11640 30 {
lab=#net145}
N 12140 80 12190 80 {
lab=GND}
N 12140 -20 12190 -20 {
lab=VDD}
N 12070 80 12100 80 {
lab=#net149}
N 12070 -20 12100 -20 {
lab=#net149}
N 12140 30 12140 50 {
lab=#net150}
N 12190 80 12190 310 {
lab=GND}
N 12140 110 12140 230 {
lab=#net151}
N 12140 -250 12140 -170 {lab=VDD}
N 12100 -170 12100 -110 {lab=#net3}
N 12100 190 12100 260 {lab=VCtrl}
N 12140 -140 12140 -50 {lab=#net152}
N 12140 260 12140 310 {lab=GND}
N 12190 -250 12190 -20 {lab=VDD}
N 12140 -250 12190 -250 {lab=VDD}
N 12140 310 12190 310 {lab=GND}
N 11890 -250 12140 -250 {lab=VDD}
N 12070 30 12070 80 {lab=#net149}
N 11890 30 12070 30 {lab=#net149}
N 12070 -20 12070 30 {lab=#net149}
N 11890 10 11890 30 {
lab=#net149}
N 11670 -110 12100 -110 {lab=#net3}
N 11670 190 12100 190 {lab=VCtrl}
N 11450 10 11450 30 {
lab=#net145}
N 11450 310 11710 310 {lab=GND}
N 11320 310 11450 310 {lab=GND}
N 11230 190 11670 190 {lab=VCtrl}
N 11230 -110 11670 -110 {lab=#net3}
N 11450 -250 11710 -250 {lab=VDD}
N 11020 80 11020 310 {lab=GND}
N 10890 310 11020 310 {lab=GND}
N 11890 80 11890 310 {lab=GND}
N 11760 310 11890 310 {lab=GND}
N 12250 80 12280 80 {
lab=#net150}
N 12250 -20 12280 -20 {
lab=#net150}
N 12250 30 12250 80 {
lab=#net150}
N 12140 30 12250 30 {
lab=#net150}
N 12250 -20 12250 30 {
lab=#net150}
N 12190 -250 12320 -250 {lab=VDD}
N 12320 -250 12320 -20 {lab=VDD}
N 12320 30 12320 50 {
lab=out}
N 12320 310 12570 310 {lab=GND}
N 12320 -250 12570 -250 {lab=VDD}
N 12320 30 12500 30 {lab=out}
N 12320 10 12320 30 {
lab=out}
N 12100 -110 12530 -110 {lab=#net3}
N 12100 190 12530 190 {lab=VCtrl}
N 12320 80 12320 310 {lab=GND}
N 12190 310 12320 310 {lab=GND}
N 12140 10 12140 30 {
lab=#net150}
N 10570 310 10840 310 {lab=GND}
N 10570 -250 10840 -250 {lab=VDD}
N 10570 30 10770 30 {lab=#net137}
N 10350 -110 10800 -110 {lab=#net3}
N 10350 190 10800 190 {lab=VCtrl}
N -310 990 -280 990 {
lab=#net38}
N -310 890 -280 890 {
lab=#net38}
N -310 940 -310 990 {
lab=#net38}
N -360 660 -240 660 {lab=VDD}
N -240 660 -240 890 {lab=VDD}
N -240 940 -240 960 {
lab=#net153}
N -240 920 -240 940 {
lab=#net153}
N -240 990 -240 1220 {lab=GND}
N -360 1220 -240 1220 {lab=GND}
N 160 990 190 990 {
lab=#net154}
N 160 890 190 890 {
lab=#net154}
N 160 940 160 990 {
lab=#net154}
N 50 990 100 990 {
lab=GND}
N 50 890 100 890 {
lab=VDD}
N 50 940 50 960 {
lab=#net154}
N -20 990 10 990 {
lab=#net153}
N -20 890 10 890 {
lab=#net153}
N 50 920 50 940 {
lab=#net154}
N 50 940 160 940 {
lab=#net154}
N 160 890 160 940 {
lab=#net154}
N -20 940 -20 990 {
lab=#net153}
N 100 990 100 1220 {
lab=GND}
N 50 1020 50 1140 {
lab=#net155}
N 100 660 230 660 {lab=VDD}
N 50 660 50 740 {lab=VDD}
N 230 660 230 890 {lab=VDD}
N 10 740 10 800 {lab=#net26}
N 10 1100 10 1170 {lab=VCtrl}
N 50 770 50 860 {lab=#net156}
N 50 1170 50 1220 {lab=GND}
N 100 660 100 890 {lab=VDD}
N 50 660 100 660 {lab=VDD}
N 50 1220 100 1220 {lab=GND}
N 230 940 230 960 {
lab=#net157}
N 230 1220 480 1220 {lab=GND}
N -20 890 -20 940 {
lab=#net153}
N 590 990 620 990 {
lab=#net158}
N 590 890 620 890 {
lab=#net158}
N 590 940 590 990 {
lab=#net158}
N 480 990 530 990 {
lab=GND}
N 480 890 530 890 {
lab=VDD}
N 480 940 480 960 {
lab=#net158}
N 410 990 440 990 {
lab=#net157}
N 410 890 440 890 {
lab=#net157}
N 480 920 480 940 {
lab=#net158}
N 480 940 590 940 {
lab=#net158}
N 590 890 590 940 {
lab=#net158}
N 530 990 530 1220 {
lab=GND}
N 480 1020 480 1140 {
lab=#net159}
N 530 660 660 660 {lab=VDD}
N 480 660 480 740 {lab=VDD}
N 660 660 660 890 {lab=VDD}
N 440 740 440 800 {lab=#net26}
N 440 1100 440 1170 {lab=VCtrl}
N 480 770 480 860 {lab=#net160}
N 480 1170 480 1220 {lab=GND}
N 530 660 530 890 {lab=VDD}
N 480 660 530 660 {lab=VDD}
N 480 1220 530 1220 {lab=GND}
N 660 940 660 960 {
lab=#net161}
N 660 990 660 1220 {lab=GND}
N 230 660 480 660 {lab=VDD}
N 410 940 410 990 {lab=#net157}
N 230 940 410 940 {lab=#net157}
N 410 890 410 940 {lab=#net157}
N 230 920 230 940 {
lab=#net157}
N 10 800 440 800 {lab=#net26}
N 10 1100 440 1100 {lab=VCtrl}
N 1030 990 1060 990 {
lab=#net162}
N 1030 890 1060 890 {
lab=#net162}
N 1030 940 1030 990 {
lab=#net162}
N 920 990 970 990 {
lab=GND}
N 920 890 970 890 {
lab=VDD}
N 920 940 920 960 {
lab=#net162}
N 850 990 880 990 {
lab=#net161}
N 850 890 880 890 {
lab=#net161}
N 920 920 920 940 {
lab=#net162}
N 920 940 1030 940 {
lab=#net162}
N 1030 890 1030 940 {
lab=#net162}
N 850 940 850 990 {
lab=#net161}
N 970 990 970 1220 {
lab=GND}
N 920 1020 920 1140 {
lab=#net163}
N 970 660 1100 660 {lab=VDD}
N 920 660 920 740 {lab=VDD}
N 1100 660 1100 890 {lab=VDD}
N 880 740 880 800 {lab=#net26}
N 880 1100 880 1170 {lab=VCtrl}
N 920 770 920 860 {lab=#net164}
N 920 1170 920 1220 {lab=GND}
N 970 660 970 890 {lab=VDD}
N 920 660 970 660 {lab=VDD}
N 920 1220 970 1220 {lab=GND}
N 1100 940 1100 960 {
lab=#net165}
N 1100 1220 1350 1220 {lab=GND}
N 660 940 850 940 {lab=#net161}
N 850 890 850 940 {
lab=#net161}
N 1350 990 1400 990 {
lab=GND}
N 1350 890 1400 890 {
lab=VDD}
N 1280 990 1310 990 {
lab=#net165}
N 1280 890 1310 890 {
lab=#net165}
N 1350 940 1350 960 {
lab=#net166}
N 1400 990 1400 1220 {
lab=GND}
N 1350 1020 1350 1140 {
lab=#net167}
N 1350 660 1350 740 {lab=VDD}
N 1310 740 1310 800 {lab=#net26}
N 1310 1100 1310 1170 {lab=VCtrl}
N 1350 770 1350 860 {lab=#net168}
N 1350 1170 1350 1220 {lab=GND}
N 1400 660 1400 890 {lab=VDD}
N 1350 660 1400 660 {lab=VDD}
N 1350 1220 1400 1220 {lab=GND}
N 1100 660 1350 660 {lab=VDD}
N 1280 940 1280 990 {lab=#net165}
N 1100 940 1280 940 {lab=#net165}
N 1280 890 1280 940 {lab=#net165}
N 1100 920 1100 940 {
lab=#net165}
N 880 800 1310 800 {lab=#net26}
N 880 1100 1310 1100 {lab=VCtrl}
N 660 920 660 940 {
lab=#net161}
N 660 1220 920 1220 {lab=GND}
N 530 1220 660 1220 {lab=GND}
N 440 1100 880 1100 {lab=VCtrl}
N 440 800 880 800 {lab=#net26}
N 660 660 920 660 {lab=VDD}
N 230 990 230 1220 {lab=GND}
N 100 1220 230 1220 {lab=GND}
N 1100 990 1100 1220 {lab=GND}
N 970 1220 1100 1220 {lab=GND}
N 1460 990 1490 990 {
lab=#net166}
N 1460 890 1490 890 {
lab=#net166}
N 1460 940 1460 990 {
lab=#net166}
N 1350 940 1460 940 {
lab=#net166}
N 1460 890 1460 940 {
lab=#net166}
N 1400 660 1530 660 {lab=VDD}
N 1530 660 1530 890 {lab=VDD}
N 1530 940 1530 960 {
lab=#net169}
N 1530 920 1530 940 {
lab=#net169}
N 1530 990 1530 1220 {lab=GND}
N 1400 1220 1530 1220 {lab=GND}
N 1350 920 1350 940 {
lab=#net166}
N -240 1220 50 1220 {lab=GND}
N -240 660 50 660 {lab=VDD}
N -240 940 -20 940 {lab=#net153}
N -450 800 10 800 {lab=#net26}
N -450 1100 10 1100 {lab=VCtrl}
N 1990 990 2020 990 {
lab=#net170}
N 1990 890 2020 890 {
lab=#net170}
N 1990 940 1990 990 {
lab=#net170}
N 1880 990 1930 990 {
lab=GND}
N 1880 890 1930 890 {
lab=VDD}
N 1880 940 1880 960 {
lab=#net170}
N 1810 990 1840 990 {
lab=#net169}
N 1810 890 1840 890 {
lab=#net169}
N 1880 920 1880 940 {
lab=#net170}
N 1880 940 1990 940 {
lab=#net170}
N 1990 890 1990 940 {
lab=#net170}
N 1810 940 1810 990 {
lab=#net169}
N 1930 990 1930 1220 {
lab=GND}
N 1880 1020 1880 1140 {
lab=#net171}
N 1930 660 2060 660 {lab=VDD}
N 1880 660 1880 740 {lab=VDD}
N 2060 660 2060 890 {lab=VDD}
N 1840 740 1840 800 {lab=#net26}
N 1840 1100 1840 1170 {lab=VCtrl}
N 1880 770 1880 860 {lab=#net172}
N 1880 1170 1880 1220 {lab=GND}
N 1930 660 1930 890 {lab=VDD}
N 1880 660 1930 660 {lab=VDD}
N 1880 1220 1930 1220 {lab=GND}
N 2060 940 2060 960 {
lab=#net173}
N 2060 1220 2310 1220 {lab=GND}
N 1810 890 1810 940 {
lab=#net169}
N 2420 990 2450 990 {
lab=#net174}
N 2420 890 2450 890 {
lab=#net174}
N 2420 940 2420 990 {
lab=#net174}
N 2310 990 2360 990 {
lab=GND}
N 2310 890 2360 890 {
lab=VDD}
N 2310 940 2310 960 {
lab=#net174}
N 2240 990 2270 990 {
lab=#net173}
N 2240 890 2270 890 {
lab=#net173}
N 2310 920 2310 940 {
lab=#net174}
N 2310 940 2420 940 {
lab=#net174}
N 2420 890 2420 940 {
lab=#net174}
N 2360 990 2360 1220 {
lab=GND}
N 2310 1020 2310 1140 {
lab=#net175}
N 2360 660 2490 660 {lab=VDD}
N 2310 660 2310 740 {lab=VDD}
N 2490 660 2490 890 {lab=VDD}
N 2270 740 2270 800 {lab=#net26}
N 2270 1100 2270 1170 {lab=VCtrl}
N 2310 770 2310 860 {lab=#net176}
N 2310 1170 2310 1220 {lab=GND}
N 2360 660 2360 890 {lab=VDD}
N 2310 660 2360 660 {lab=VDD}
N 2310 1220 2360 1220 {lab=GND}
N 2490 940 2490 960 {
lab=#net177}
N 2490 990 2490 1220 {lab=GND}
N 2060 660 2310 660 {lab=VDD}
N 2240 940 2240 990 {lab=#net173}
N 2060 940 2240 940 {lab=#net173}
N 2240 890 2240 940 {lab=#net173}
N 2060 920 2060 940 {
lab=#net173}
N 1840 800 2270 800 {lab=#net26}
N 1840 1100 2270 1100 {lab=VCtrl}
N 2860 990 2890 990 {
lab=#net178}
N 2860 890 2890 890 {
lab=#net178}
N 2860 940 2860 990 {
lab=#net178}
N 2750 990 2800 990 {
lab=GND}
N 2750 890 2800 890 {
lab=VDD}
N 2750 940 2750 960 {
lab=#net178}
N 2680 990 2710 990 {
lab=#net177}
N 2680 890 2710 890 {
lab=#net177}
N 2750 920 2750 940 {
lab=#net178}
N 2750 940 2860 940 {
lab=#net178}
N 2860 890 2860 940 {
lab=#net178}
N 2680 940 2680 990 {
lab=#net177}
N 2800 990 2800 1220 {
lab=GND}
N 2750 1020 2750 1140 {
lab=#net179}
N 2800 660 2930 660 {lab=VDD}
N 2750 660 2750 740 {lab=VDD}
N 2930 660 2930 890 {lab=VDD}
N 2710 740 2710 800 {lab=#net26}
N 2710 1100 2710 1170 {lab=VCtrl}
N 2750 770 2750 860 {lab=#net180}
N 2750 1170 2750 1220 {lab=GND}
N 2800 660 2800 890 {lab=VDD}
N 2750 660 2800 660 {lab=VDD}
N 2750 1220 2800 1220 {lab=GND}
N 2930 940 2930 960 {
lab=#net181}
N 2930 1220 3180 1220 {lab=GND}
N 2490 940 2680 940 {lab=#net177}
N 2680 890 2680 940 {
lab=#net177}
N 3180 990 3230 990 {
lab=GND}
N 3180 890 3230 890 {
lab=VDD}
N 3110 990 3140 990 {
lab=#net181}
N 3110 890 3140 890 {
lab=#net181}
N 3180 940 3180 960 {
lab=#net182}
N 3230 990 3230 1220 {
lab=GND}
N 3180 1020 3180 1140 {
lab=#net183}
N 3180 660 3180 740 {lab=VDD}
N 3140 740 3140 800 {lab=#net26}
N 3140 1100 3140 1170 {lab=VCtrl}
N 3180 770 3180 860 {lab=#net184}
N 3180 1170 3180 1220 {lab=GND}
N 3230 660 3230 890 {lab=VDD}
N 3180 660 3230 660 {lab=VDD}
N 3180 1220 3230 1220 {lab=GND}
N 2930 660 3180 660 {lab=VDD}
N 3110 940 3110 990 {lab=#net181}
N 2930 940 3110 940 {lab=#net181}
N 3110 890 3110 940 {lab=#net181}
N 2930 920 2930 940 {
lab=#net181}
N 2710 800 3140 800 {lab=#net26}
N 2710 1100 3140 1100 {lab=VCtrl}
N 2490 920 2490 940 {
lab=#net177}
N 2490 1220 2750 1220 {lab=GND}
N 2360 1220 2490 1220 {lab=GND}
N 2270 1100 2710 1100 {lab=VCtrl}
N 2270 800 2710 800 {lab=#net26}
N 2490 660 2750 660 {lab=VDD}
N 2060 990 2060 1220 {lab=GND}
N 1930 1220 2060 1220 {lab=GND}
N 2930 990 2930 1220 {lab=GND}
N 2800 1220 2930 1220 {lab=GND}
N 3290 990 3320 990 {
lab=#net182}
N 3290 890 3320 890 {
lab=#net182}
N 3290 940 3290 990 {
lab=#net182}
N 3180 940 3290 940 {
lab=#net182}
N 3290 890 3290 940 {
lab=#net182}
N 3230 660 3360 660 {lab=VDD}
N 3360 660 3360 890 {lab=VDD}
N 3360 940 3360 960 {
lab=#net185}
N 3360 920 3360 940 {
lab=#net185}
N 3360 990 3360 1220 {lab=GND}
N 3230 1220 3360 1220 {lab=GND}
N 3180 920 3180 940 {
lab=#net182}
N 1530 1220 1880 1220 {lab=GND}
N 1530 660 1880 660 {lab=VDD}
N 1530 940 1810 940 {lab=#net169}
N 1310 800 1840 800 {lab=#net26}
N 1310 1100 1840 1100 {lab=VCtrl}
N 3810 990 3840 990 {
lab=#net186}
N 3810 890 3840 890 {
lab=#net186}
N 3810 940 3810 990 {
lab=#net186}
N 3700 990 3750 990 {
lab=GND}
N 3700 890 3750 890 {
lab=VDD}
N 3700 940 3700 960 {
lab=#net186}
N 3630 990 3660 990 {
lab=#net185}
N 3630 890 3660 890 {
lab=#net185}
N 3700 920 3700 940 {
lab=#net186}
N 3700 940 3810 940 {
lab=#net186}
N 3810 890 3810 940 {
lab=#net186}
N 3630 940 3630 990 {
lab=#net185}
N 3750 990 3750 1220 {
lab=GND}
N 3700 1020 3700 1140 {
lab=#net187}
N 3750 660 3880 660 {lab=VDD}
N 3700 660 3700 740 {lab=VDD}
N 3880 660 3880 890 {lab=VDD}
N 3660 740 3660 800 {lab=#net26}
N 3660 1100 3660 1170 {lab=VCtrl}
N 3700 770 3700 860 {lab=#net188}
N 3700 1170 3700 1220 {lab=GND}
N 3750 660 3750 890 {lab=VDD}
N 3700 660 3750 660 {lab=VDD}
N 3700 1220 3750 1220 {lab=GND}
N 3880 940 3880 960 {
lab=#net189}
N 3880 1220 4130 1220 {lab=GND}
N 3630 890 3630 940 {
lab=#net185}
N 4240 990 4270 990 {
lab=#net190}
N 4240 890 4270 890 {
lab=#net190}
N 4240 940 4240 990 {
lab=#net190}
N 4130 990 4180 990 {
lab=GND}
N 4130 890 4180 890 {
lab=VDD}
N 4130 940 4130 960 {
lab=#net190}
N 4060 990 4090 990 {
lab=#net189}
N 4060 890 4090 890 {
lab=#net189}
N 4130 920 4130 940 {
lab=#net190}
N 4130 940 4240 940 {
lab=#net190}
N 4240 890 4240 940 {
lab=#net190}
N 4180 990 4180 1220 {
lab=GND}
N 4130 1020 4130 1140 {
lab=#net191}
N 4180 660 4310 660 {lab=VDD}
N 4130 660 4130 740 {lab=VDD}
N 4310 660 4310 890 {lab=VDD}
N 4090 740 4090 800 {lab=#net26}
N 4090 1100 4090 1170 {lab=VCtrl}
N 4130 770 4130 860 {lab=#net192}
N 4130 1170 4130 1220 {lab=GND}
N 4180 660 4180 890 {lab=VDD}
N 4130 660 4180 660 {lab=VDD}
N 4130 1220 4180 1220 {lab=GND}
N 4310 940 4310 960 {
lab=#net193}
N 4310 990 4310 1220 {lab=GND}
N 3880 660 4130 660 {lab=VDD}
N 4060 940 4060 990 {lab=#net189}
N 3880 940 4060 940 {lab=#net189}
N 4060 890 4060 940 {lab=#net189}
N 3880 920 3880 940 {
lab=#net189}
N 3660 800 4090 800 {lab=#net26}
N 3660 1100 4090 1100 {lab=VCtrl}
N 4680 990 4710 990 {
lab=#net194}
N 4680 890 4710 890 {
lab=#net194}
N 4680 940 4680 990 {
lab=#net194}
N 4570 990 4620 990 {
lab=GND}
N 4570 890 4620 890 {
lab=VDD}
N 4570 940 4570 960 {
lab=#net194}
N 4500 990 4530 990 {
lab=#net193}
N 4500 890 4530 890 {
lab=#net193}
N 4570 920 4570 940 {
lab=#net194}
N 4570 940 4680 940 {
lab=#net194}
N 4680 890 4680 940 {
lab=#net194}
N 4500 940 4500 990 {
lab=#net193}
N 4620 990 4620 1220 {
lab=GND}
N 4570 1020 4570 1140 {
lab=#net195}
N 4620 660 4750 660 {lab=VDD}
N 4570 660 4570 740 {lab=VDD}
N 4750 660 4750 890 {lab=VDD}
N 4530 740 4530 800 {lab=#net26}
N 4530 1100 4530 1170 {lab=VCtrl}
N 4570 770 4570 860 {lab=#net196}
N 4570 1170 4570 1220 {lab=GND}
N 4620 660 4620 890 {lab=VDD}
N 4570 660 4620 660 {lab=VDD}
N 4570 1220 4620 1220 {lab=GND}
N 4750 940 4750 960 {
lab=#net197}
N 4750 1220 5000 1220 {lab=GND}
N 4310 940 4500 940 {lab=#net193}
N 4500 890 4500 940 {
lab=#net193}
N 5000 990 5050 990 {
lab=GND}
N 5000 890 5050 890 {
lab=VDD}
N 4930 990 4960 990 {
lab=#net197}
N 4930 890 4960 890 {
lab=#net197}
N 5000 940 5000 960 {
lab=#net198}
N 5050 990 5050 1220 {
lab=GND}
N 5000 1020 5000 1140 {
lab=#net199}
N 5000 660 5000 740 {lab=VDD}
N 4960 740 4960 800 {lab=#net26}
N 4960 1100 4960 1170 {lab=VCtrl}
N 5000 770 5000 860 {lab=#net200}
N 5000 1170 5000 1220 {lab=GND}
N 5050 660 5050 890 {lab=VDD}
N 5000 660 5050 660 {lab=VDD}
N 5000 1220 5050 1220 {lab=GND}
N 4750 660 5000 660 {lab=VDD}
N 4930 940 4930 990 {lab=#net197}
N 4750 940 4930 940 {lab=#net197}
N 4930 890 4930 940 {lab=#net197}
N 4750 920 4750 940 {
lab=#net197}
N 4530 800 4960 800 {lab=#net26}
N 4530 1100 4960 1100 {lab=VCtrl}
N 4310 920 4310 940 {
lab=#net193}
N 4310 1220 4570 1220 {lab=GND}
N 4180 1220 4310 1220 {lab=GND}
N 4090 1100 4530 1100 {lab=VCtrl}
N 4090 800 4530 800 {lab=#net26}
N 4310 660 4570 660 {lab=VDD}
N 3880 990 3880 1220 {lab=GND}
N 3750 1220 3880 1220 {lab=GND}
N 4750 990 4750 1220 {lab=GND}
N 4620 1220 4750 1220 {lab=GND}
N 5110 990 5140 990 {
lab=#net198}
N 5110 890 5140 890 {
lab=#net198}
N 5110 940 5110 990 {
lab=#net198}
N 5000 940 5110 940 {
lab=#net198}
N 5110 890 5110 940 {
lab=#net198}
N 5050 660 5180 660 {lab=VDD}
N 5180 660 5180 890 {lab=VDD}
N 5180 940 5180 960 {
lab=#net201}
N 5180 920 5180 940 {
lab=#net201}
N 5180 990 5180 1220 {lab=GND}
N 5050 1220 5180 1220 {lab=GND}
N 5000 920 5000 940 {
lab=#net198}
N 3360 1220 3700 1220 {lab=GND}
N 3360 660 3700 660 {lab=VDD}
N 3360 940 3630 940 {lab=#net185}
N 3140 800 3660 800 {lab=#net26}
N 3140 1100 3660 1100 {lab=VCtrl}
N 5630 990 5660 990 {
lab=#net202}
N 5630 890 5660 890 {
lab=#net202}
N 5630 940 5630 990 {
lab=#net202}
N 5520 990 5570 990 {
lab=GND}
N 5520 890 5570 890 {
lab=VDD}
N 5520 940 5520 960 {
lab=#net202}
N 5450 990 5480 990 {
lab=#net201}
N 5450 890 5480 890 {
lab=#net201}
N 5520 920 5520 940 {
lab=#net202}
N 5520 940 5630 940 {
lab=#net202}
N 5630 890 5630 940 {
lab=#net202}
N 5450 940 5450 990 {
lab=#net201}
N 5570 990 5570 1220 {
lab=GND}
N 5520 1020 5520 1140 {
lab=#net203}
N 5570 660 5700 660 {lab=VDD}
N 5520 660 5520 740 {lab=VDD}
N 5700 660 5700 890 {lab=VDD}
N 5480 740 5480 800 {lab=#net26}
N 5480 1100 5480 1170 {lab=VCtrl}
N 5520 770 5520 860 {lab=#net204}
N 5520 1170 5520 1220 {lab=GND}
N 5570 660 5570 890 {lab=VDD}
N 5520 660 5570 660 {lab=VDD}
N 5520 1220 5570 1220 {lab=GND}
N 5700 940 5700 960 {
lab=#net205}
N 5700 1220 5950 1220 {lab=GND}
N 5450 890 5450 940 {
lab=#net201}
N 6060 990 6090 990 {
lab=#net206}
N 6060 890 6090 890 {
lab=#net206}
N 6060 940 6060 990 {
lab=#net206}
N 5950 990 6000 990 {
lab=GND}
N 5950 890 6000 890 {
lab=VDD}
N 5950 940 5950 960 {
lab=#net206}
N 5880 990 5910 990 {
lab=#net205}
N 5880 890 5910 890 {
lab=#net205}
N 5950 920 5950 940 {
lab=#net206}
N 5950 940 6060 940 {
lab=#net206}
N 6060 890 6060 940 {
lab=#net206}
N 6000 990 6000 1220 {
lab=GND}
N 5950 1020 5950 1140 {
lab=#net207}
N 6000 660 6130 660 {lab=VDD}
N 5950 660 5950 740 {lab=VDD}
N 6130 660 6130 890 {lab=VDD}
N 5910 740 5910 800 {lab=#net26}
N 5910 1100 5910 1170 {lab=VCtrl}
N 5950 770 5950 860 {lab=#net208}
N 5950 1170 5950 1220 {lab=GND}
N 6000 660 6000 890 {lab=VDD}
N 5950 660 6000 660 {lab=VDD}
N 5950 1220 6000 1220 {lab=GND}
N 6130 940 6130 960 {
lab=#net209}
N 6130 990 6130 1220 {lab=GND}
N 5700 660 5950 660 {lab=VDD}
N 5880 940 5880 990 {lab=#net205}
N 5700 940 5880 940 {lab=#net205}
N 5880 890 5880 940 {lab=#net205}
N 5700 920 5700 940 {
lab=#net205}
N 5480 800 5910 800 {lab=#net26}
N 5480 1100 5910 1100 {lab=VCtrl}
N 6500 990 6530 990 {
lab=#net210}
N 6500 890 6530 890 {
lab=#net210}
N 6500 940 6500 990 {
lab=#net210}
N 6390 990 6440 990 {
lab=GND}
N 6390 890 6440 890 {
lab=VDD}
N 6390 940 6390 960 {
lab=#net210}
N 6320 990 6350 990 {
lab=#net209}
N 6320 890 6350 890 {
lab=#net209}
N 6390 920 6390 940 {
lab=#net210}
N 6390 940 6500 940 {
lab=#net210}
N 6500 890 6500 940 {
lab=#net210}
N 6320 940 6320 990 {
lab=#net209}
N 6440 990 6440 1220 {
lab=GND}
N 6390 1020 6390 1140 {
lab=#net211}
N 6440 660 6570 660 {lab=VDD}
N 6390 660 6390 740 {lab=VDD}
N 6570 660 6570 890 {lab=VDD}
N 6350 740 6350 800 {lab=#net26}
N 6350 1100 6350 1170 {lab=VCtrl}
N 6390 770 6390 860 {lab=#net212}
N 6390 1170 6390 1220 {lab=GND}
N 6440 660 6440 890 {lab=VDD}
N 6390 660 6440 660 {lab=VDD}
N 6390 1220 6440 1220 {lab=GND}
N 6570 940 6570 960 {
lab=#net213}
N 6570 1220 6820 1220 {lab=GND}
N 6130 940 6320 940 {lab=#net209}
N 6320 890 6320 940 {
lab=#net209}
N 6820 990 6870 990 {
lab=GND}
N 6820 890 6870 890 {
lab=VDD}
N 6750 990 6780 990 {
lab=#net213}
N 6750 890 6780 890 {
lab=#net213}
N 6820 940 6820 960 {
lab=#net214}
N 6870 990 6870 1220 {
lab=GND}
N 6820 1020 6820 1140 {
lab=#net215}
N 6820 660 6820 740 {lab=VDD}
N 6780 740 6780 800 {lab=#net26}
N 6780 1100 6780 1170 {lab=VCtrl}
N 6820 770 6820 860 {lab=#net216}
N 6820 1170 6820 1220 {lab=GND}
N 6870 660 6870 890 {lab=VDD}
N 6820 660 6870 660 {lab=VDD}
N 6820 1220 6870 1220 {lab=GND}
N 6570 660 6820 660 {lab=VDD}
N 6750 940 6750 990 {lab=#net213}
N 6570 940 6750 940 {lab=#net213}
N 6750 890 6750 940 {lab=#net213}
N 6570 920 6570 940 {
lab=#net213}
N 6350 800 6780 800 {lab=#net26}
N 6350 1100 6780 1100 {lab=VCtrl}
N 6130 920 6130 940 {
lab=#net209}
N 6130 1220 6390 1220 {lab=GND}
N 6000 1220 6130 1220 {lab=GND}
N 5910 1100 6350 1100 {lab=VCtrl}
N 5910 800 6350 800 {lab=#net26}
N 6130 660 6390 660 {lab=VDD}
N 5700 990 5700 1220 {lab=GND}
N 5570 1220 5700 1220 {lab=GND}
N 6570 990 6570 1220 {lab=GND}
N 6440 1220 6570 1220 {lab=GND}
N 6930 990 6960 990 {
lab=#net214}
N 6930 890 6960 890 {
lab=#net214}
N 6930 940 6930 990 {
lab=#net214}
N 6820 940 6930 940 {
lab=#net214}
N 6930 890 6930 940 {
lab=#net214}
N 6870 660 7000 660 {lab=VDD}
N 7000 660 7000 890 {lab=VDD}
N 7000 940 7000 960 {
lab=#net217}
N 7000 920 7000 940 {
lab=#net217}
N 7000 990 7000 1220 {lab=GND}
N 6870 1220 7000 1220 {lab=GND}
N 6820 920 6820 940 {
lab=#net214}
N 5180 1220 5520 1220 {lab=GND}
N 5180 660 5520 660 {lab=VDD}
N 5180 940 5450 940 {lab=#net201}
N 4960 800 5480 800 {lab=#net26}
N 4960 1100 5480 1100 {lab=VCtrl}
N 7430 990 7460 990 {
lab=#net218}
N 7430 890 7460 890 {
lab=#net218}
N 7430 940 7430 990 {
lab=#net218}
N 7320 990 7370 990 {
lab=GND}
N 7320 890 7370 890 {
lab=VDD}
N 7320 940 7320 960 {
lab=#net218}
N 7250 990 7280 990 {
lab=#net217}
N 7250 890 7280 890 {
lab=#net217}
N 7320 920 7320 940 {
lab=#net218}
N 7320 940 7430 940 {
lab=#net218}
N 7430 890 7430 940 {
lab=#net218}
N 7250 940 7250 990 {
lab=#net217}
N 7370 990 7370 1220 {
lab=GND}
N 7320 1020 7320 1140 {
lab=#net219}
N 7370 660 7500 660 {lab=VDD}
N 7320 660 7320 740 {lab=VDD}
N 7500 660 7500 890 {lab=VDD}
N 7280 740 7280 800 {lab=#net26}
N 7280 1100 7280 1170 {lab=VCtrl}
N 7320 770 7320 860 {lab=#net220}
N 7320 1170 7320 1220 {lab=GND}
N 7370 660 7370 890 {lab=VDD}
N 7320 660 7370 660 {lab=VDD}
N 7320 1220 7370 1220 {lab=GND}
N 7500 940 7500 960 {
lab=#net221}
N 7500 1220 7750 1220 {lab=GND}
N 7250 890 7250 940 {
lab=#net217}
N 7860 990 7890 990 {
lab=#net222}
N 7860 890 7890 890 {
lab=#net222}
N 7860 940 7860 990 {
lab=#net222}
N 7750 990 7800 990 {
lab=GND}
N 7750 890 7800 890 {
lab=VDD}
N 7750 940 7750 960 {
lab=#net222}
N 7680 990 7710 990 {
lab=#net221}
N 7680 890 7710 890 {
lab=#net221}
N 7750 920 7750 940 {
lab=#net222}
N 7750 940 7860 940 {
lab=#net222}
N 7860 890 7860 940 {
lab=#net222}
N 7800 990 7800 1220 {
lab=GND}
N 7750 1020 7750 1140 {
lab=#net223}
N 7800 660 7930 660 {lab=VDD}
N 7750 660 7750 740 {lab=VDD}
N 7930 660 7930 890 {lab=VDD}
N 7710 740 7710 800 {lab=#net26}
N 7710 1100 7710 1170 {lab=VCtrl}
N 7750 770 7750 860 {lab=#net224}
N 7750 1170 7750 1220 {lab=GND}
N 7800 660 7800 890 {lab=VDD}
N 7750 660 7800 660 {lab=VDD}
N 7750 1220 7800 1220 {lab=GND}
N 7930 940 7930 960 {
lab=#net225}
N 7930 990 7930 1220 {lab=GND}
N 7500 660 7750 660 {lab=VDD}
N 7680 940 7680 990 {lab=#net221}
N 7500 940 7680 940 {lab=#net221}
N 7680 890 7680 940 {lab=#net221}
N 7500 920 7500 940 {
lab=#net221}
N 7280 800 7710 800 {lab=#net26}
N 7280 1100 7710 1100 {lab=VCtrl}
N 8300 990 8330 990 {
lab=#net226}
N 8300 890 8330 890 {
lab=#net226}
N 8300 940 8300 990 {
lab=#net226}
N 8190 990 8240 990 {
lab=GND}
N 8190 890 8240 890 {
lab=VDD}
N 8190 940 8190 960 {
lab=#net226}
N 8120 990 8150 990 {
lab=#net225}
N 8120 890 8150 890 {
lab=#net225}
N 8190 920 8190 940 {
lab=#net226}
N 8190 940 8300 940 {
lab=#net226}
N 8300 890 8300 940 {
lab=#net226}
N 8120 940 8120 990 {
lab=#net225}
N 8240 990 8240 1220 {
lab=GND}
N 8190 1020 8190 1140 {
lab=#net227}
N 8240 660 8370 660 {lab=VDD}
N 8190 660 8190 740 {lab=VDD}
N 8370 660 8370 890 {lab=VDD}
N 8150 740 8150 800 {lab=#net26}
N 8150 1100 8150 1170 {lab=VCtrl}
N 8190 770 8190 860 {lab=#net228}
N 8190 1170 8190 1220 {lab=GND}
N 8240 660 8240 890 {lab=VDD}
N 8190 660 8240 660 {lab=VDD}
N 8190 1220 8240 1220 {lab=GND}
N 8370 940 8370 960 {
lab=#net229}
N 8370 1220 8620 1220 {lab=GND}
N 7930 940 8120 940 {lab=#net225}
N 8120 890 8120 940 {
lab=#net225}
N 8620 990 8670 990 {
lab=GND}
N 8620 890 8670 890 {
lab=VDD}
N 8550 990 8580 990 {
lab=#net229}
N 8550 890 8580 890 {
lab=#net229}
N 8620 940 8620 960 {
lab=#net230}
N 8670 990 8670 1220 {
lab=GND}
N 8620 1020 8620 1140 {
lab=#net231}
N 8620 660 8620 740 {lab=VDD}
N 8580 740 8580 800 {lab=#net26}
N 8580 1100 8580 1170 {lab=VCtrl}
N 8620 770 8620 860 {lab=#net232}
N 8620 1170 8620 1220 {lab=GND}
N 8670 660 8670 890 {lab=VDD}
N 8620 660 8670 660 {lab=VDD}
N 8620 1220 8670 1220 {lab=GND}
N 8370 660 8620 660 {lab=VDD}
N 8550 940 8550 990 {lab=#net229}
N 8370 940 8550 940 {lab=#net229}
N 8550 890 8550 940 {lab=#net229}
N 8370 920 8370 940 {
lab=#net229}
N 8150 800 8580 800 {lab=#net26}
N 8150 1100 8580 1100 {lab=VCtrl}
N 7930 920 7930 940 {
lab=#net225}
N 7930 1220 8190 1220 {lab=GND}
N 7800 1220 7930 1220 {lab=GND}
N 7710 1100 8150 1100 {lab=VCtrl}
N 7710 800 8150 800 {lab=#net26}
N 7930 660 8190 660 {lab=VDD}
N 7500 990 7500 1220 {lab=GND}
N 7370 1220 7500 1220 {lab=GND}
N 8370 990 8370 1220 {lab=GND}
N 8240 1220 8370 1220 {lab=GND}
N 8730 990 8760 990 {
lab=#net230}
N 8730 890 8760 890 {
lab=#net230}
N 8730 940 8730 990 {
lab=#net230}
N 8620 940 8730 940 {
lab=#net230}
N 8730 890 8730 940 {
lab=#net230}
N 8670 660 8800 660 {lab=VDD}
N 8800 660 8800 890 {lab=VDD}
N 8800 940 8800 960 {
lab=#net233}
N 8800 920 8800 940 {
lab=#net233}
N 8800 990 8800 1220 {lab=GND}
N 8670 1220 8800 1220 {lab=GND}
N 8620 920 8620 940 {
lab=#net230}
N 7000 1220 7320 1220 {lab=GND}
N 7000 660 7320 660 {lab=VDD}
N 7000 940 7250 940 {lab=#net217}
N 6780 800 7280 800 {lab=#net26}
N 6780 1100 7280 1100 {lab=VCtrl}
N 9190 990 9220 990 {
lab=#net234}
N 9190 890 9220 890 {
lab=#net234}
N 9190 940 9190 990 {
lab=#net234}
N 9080 990 9130 990 {
lab=GND}
N 9080 890 9130 890 {
lab=VDD}
N 9080 940 9080 960 {
lab=#net234}
N 9010 990 9040 990 {
lab=#net233}
N 9010 890 9040 890 {
lab=#net233}
N 9080 920 9080 940 {
lab=#net234}
N 9080 940 9190 940 {
lab=#net234}
N 9190 890 9190 940 {
lab=#net234}
N 9010 940 9010 990 {
lab=#net233}
N 9130 990 9130 1220 {
lab=GND}
N 9080 1020 9080 1140 {
lab=#net235}
N 9130 660 9260 660 {lab=VDD}
N 9080 660 9080 740 {lab=VDD}
N 9260 660 9260 890 {lab=VDD}
N 9040 740 9040 800 {lab=#net26}
N 9040 1100 9040 1170 {lab=VCtrl}
N 9080 770 9080 860 {lab=#net236}
N 9080 1170 9080 1220 {lab=GND}
N 9130 660 9130 890 {lab=VDD}
N 9080 660 9130 660 {lab=VDD}
N 9080 1220 9130 1220 {lab=GND}
N 9260 940 9260 960 {
lab=#net237}
N 9260 1220 9510 1220 {lab=GND}
N 9010 890 9010 940 {
lab=#net233}
N 9620 990 9650 990 {
lab=#net238}
N 9620 890 9650 890 {
lab=#net238}
N 9620 940 9620 990 {
lab=#net238}
N 9510 990 9560 990 {
lab=GND}
N 9510 890 9560 890 {
lab=VDD}
N 9510 940 9510 960 {
lab=#net238}
N 9440 990 9470 990 {
lab=#net237}
N 9440 890 9470 890 {
lab=#net237}
N 9510 920 9510 940 {
lab=#net238}
N 9510 940 9620 940 {
lab=#net238}
N 9620 890 9620 940 {
lab=#net238}
N 9560 990 9560 1220 {
lab=GND}
N 9510 1020 9510 1140 {
lab=#net239}
N 9560 660 9690 660 {lab=VDD}
N 9510 660 9510 740 {lab=VDD}
N 9690 660 9690 890 {lab=VDD}
N 9470 740 9470 800 {lab=#net26}
N 9470 1100 9470 1170 {lab=VCtrl}
N 9510 770 9510 860 {lab=#net240}
N 9510 1170 9510 1220 {lab=GND}
N 9560 660 9560 890 {lab=VDD}
N 9510 660 9560 660 {lab=VDD}
N 9510 1220 9560 1220 {lab=GND}
N 9690 940 9690 960 {
lab=#net241}
N 9690 990 9690 1220 {lab=GND}
N 9260 660 9510 660 {lab=VDD}
N 9440 940 9440 990 {lab=#net237}
N 9260 940 9440 940 {lab=#net237}
N 9440 890 9440 940 {lab=#net237}
N 9260 920 9260 940 {
lab=#net237}
N 9040 800 9470 800 {lab=#net26}
N 9040 1100 9470 1100 {lab=VCtrl}
N 10060 990 10090 990 {
lab=#net242}
N 10060 890 10090 890 {
lab=#net242}
N 10060 940 10060 990 {
lab=#net242}
N 9950 990 10000 990 {
lab=GND}
N 9950 890 10000 890 {
lab=VDD}
N 9950 940 9950 960 {
lab=#net242}
N 9880 990 9910 990 {
lab=#net241}
N 9880 890 9910 890 {
lab=#net241}
N 9950 920 9950 940 {
lab=#net242}
N 9950 940 10060 940 {
lab=#net242}
N 10060 890 10060 940 {
lab=#net242}
N 9880 940 9880 990 {
lab=#net241}
N 10000 990 10000 1220 {
lab=GND}
N 9950 1020 9950 1140 {
lab=#net243}
N 10000 660 10130 660 {lab=VDD}
N 9950 660 9950 740 {lab=VDD}
N 10130 660 10130 890 {lab=VDD}
N 9910 740 9910 800 {lab=#net26}
N 9910 1100 9910 1170 {lab=VCtrl}
N 9950 770 9950 860 {lab=#net244}
N 9950 1170 9950 1220 {lab=GND}
N 10000 660 10000 890 {lab=VDD}
N 9950 660 10000 660 {lab=VDD}
N 9950 1220 10000 1220 {lab=GND}
N 10130 940 10130 960 {
lab=#net245}
N 10130 1220 10380 1220 {lab=GND}
N 9690 940 9880 940 {lab=#net241}
N 9880 890 9880 940 {
lab=#net241}
N 10380 990 10430 990 {
lab=GND}
N 10380 890 10430 890 {
lab=VDD}
N 10310 990 10340 990 {
lab=#net245}
N 10310 890 10340 890 {
lab=#net245}
N 10380 940 10380 960 {
lab=#net246}
N 10430 990 10430 1220 {
lab=GND}
N 10380 1020 10380 1140 {
lab=#net247}
N 10380 660 10380 740 {lab=VDD}
N 10340 740 10340 800 {lab=#net26}
N 10340 1100 10340 1170 {lab=VCtrl}
N 10380 770 10380 860 {lab=#net248}
N 10380 1170 10380 1220 {lab=GND}
N 10430 660 10430 890 {lab=VDD}
N 10380 660 10430 660 {lab=VDD}
N 10380 1220 10430 1220 {lab=GND}
N 10130 660 10380 660 {lab=VDD}
N 10310 940 10310 990 {lab=#net245}
N 10130 940 10310 940 {lab=#net245}
N 10310 890 10310 940 {lab=#net245}
N 10130 920 10130 940 {
lab=#net245}
N 9910 800 10340 800 {lab=#net26}
N 9910 1100 10340 1100 {lab=VCtrl}
N 9690 920 9690 940 {
lab=#net241}
N 9690 1220 9950 1220 {lab=GND}
N 9560 1220 9690 1220 {lab=GND}
N 9470 1100 9910 1100 {lab=VCtrl}
N 9470 800 9910 800 {lab=#net26}
N 9690 660 9950 660 {lab=VDD}
N 9260 990 9260 1220 {lab=GND}
N 9130 1220 9260 1220 {lab=GND}
N 10130 990 10130 1220 {lab=GND}
N 10000 1220 10130 1220 {lab=GND}
N 10490 990 10520 990 {
lab=#net246}
N 10490 890 10520 890 {
lab=#net246}
N 10490 940 10490 990 {
lab=#net246}
N 10380 940 10490 940 {
lab=#net246}
N 10490 890 10490 940 {
lab=#net246}
N 10430 660 10560 660 {lab=VDD}
N 10560 660 10560 890 {lab=VDD}
N 10560 940 10560 960 {
lab=#net249}
N 10560 920 10560 940 {
lab=#net249}
N 10560 990 10560 1220 {lab=GND}
N 10430 1220 10560 1220 {lab=GND}
N 10380 920 10380 940 {
lab=#net246}
N 8800 1220 9080 1220 {lab=GND}
N 8800 660 9080 660 {lab=VDD}
N 8800 940 9010 940 {lab=#net233}
N 8580 800 9040 800 {lab=#net26}
N 8580 1100 9040 1100 {lab=VCtrl}
N 10940 990 10970 990 {
lab=#net250}
N 10940 890 10970 890 {
lab=#net250}
N 10940 940 10940 990 {
lab=#net250}
N 10830 990 10880 990 {
lab=GND}
N 10830 890 10880 890 {
lab=VDD}
N 10830 940 10830 960 {
lab=#net250}
N 10760 990 10790 990 {
lab=#net249}
N 10760 890 10790 890 {
lab=#net249}
N 10830 920 10830 940 {
lab=#net250}
N 10830 940 10940 940 {
lab=#net250}
N 10940 890 10940 940 {
lab=#net250}
N 10760 940 10760 990 {
lab=#net249}
N 10880 990 10880 1220 {
lab=GND}
N 10830 1020 10830 1140 {
lab=#net251}
N 10880 660 11010 660 {lab=VDD}
N 10830 660 10830 740 {lab=VDD}
N 11010 660 11010 890 {lab=VDD}
N 10790 740 10790 800 {lab=#net26}
N 10790 1100 10790 1170 {lab=VCtrl}
N 10830 770 10830 860 {lab=#net252}
N 10830 1170 10830 1220 {lab=GND}
N 10880 660 10880 890 {lab=VDD}
N 10830 660 10880 660 {lab=VDD}
N 10830 1220 10880 1220 {lab=GND}
N 11010 940 11010 960 {
lab=#net253}
N 11010 1220 11260 1220 {lab=GND}
N 10760 890 10760 940 {
lab=#net249}
N 11370 990 11400 990 {
lab=#net254}
N 11370 890 11400 890 {
lab=#net254}
N 11370 940 11370 990 {
lab=#net254}
N 11260 990 11310 990 {
lab=GND}
N 11260 890 11310 890 {
lab=VDD}
N 11260 940 11260 960 {
lab=#net254}
N 11190 990 11220 990 {
lab=#net253}
N 11190 890 11220 890 {
lab=#net253}
N 11260 920 11260 940 {
lab=#net254}
N 11260 940 11370 940 {
lab=#net254}
N 11370 890 11370 940 {
lab=#net254}
N 11310 990 11310 1220 {
lab=GND}
N 11260 1020 11260 1140 {
lab=#net255}
N 11310 660 11440 660 {lab=VDD}
N 11260 660 11260 740 {lab=VDD}
N 11440 660 11440 890 {lab=VDD}
N 11220 740 11220 800 {lab=#net26}
N 11220 1100 11220 1170 {lab=VCtrl}
N 11260 770 11260 860 {lab=#net256}
N 11260 1170 11260 1220 {lab=GND}
N 11310 660 11310 890 {lab=VDD}
N 11260 660 11310 660 {lab=VDD}
N 11260 1220 11310 1220 {lab=GND}
N 11440 940 11440 960 {
lab=#net257}
N 11440 990 11440 1220 {lab=GND}
N 11010 660 11260 660 {lab=VDD}
N 11190 940 11190 990 {lab=#net253}
N 11010 940 11190 940 {lab=#net253}
N 11190 890 11190 940 {lab=#net253}
N 11010 920 11010 940 {
lab=#net253}
N 10790 800 11220 800 {lab=#net26}
N 10790 1100 11220 1100 {lab=VCtrl}
N 11810 990 11840 990 {
lab=#net258}
N 11810 890 11840 890 {
lab=#net258}
N 11810 940 11810 990 {
lab=#net258}
N 11700 990 11750 990 {
lab=GND}
N 11700 890 11750 890 {
lab=VDD}
N 11700 940 11700 960 {
lab=#net258}
N 11630 990 11660 990 {
lab=#net257}
N 11630 890 11660 890 {
lab=#net257}
N 11700 920 11700 940 {
lab=#net258}
N 11700 940 11810 940 {
lab=#net258}
N 11810 890 11810 940 {
lab=#net258}
N 11630 940 11630 990 {
lab=#net257}
N 11750 990 11750 1220 {
lab=GND}
N 11700 1020 11700 1140 {
lab=#net259}
N 11750 660 11880 660 {lab=VDD}
N 11700 660 11700 740 {lab=VDD}
N 11880 660 11880 890 {lab=VDD}
N 11660 740 11660 800 {lab=#net26}
N 11660 1100 11660 1170 {lab=VCtrl}
N 11700 770 11700 860 {lab=#net260}
N 11700 1170 11700 1220 {lab=GND}
N 11750 660 11750 890 {lab=VDD}
N 11700 660 11750 660 {lab=VDD}
N 11700 1220 11750 1220 {lab=GND}
N 11880 940 11880 960 {
lab=#net261}
N 11880 1220 12130 1220 {lab=GND}
N 11440 940 11630 940 {lab=#net257}
N 11630 890 11630 940 {
lab=#net257}
N 12130 990 12180 990 {
lab=GND}
N 12130 890 12180 890 {
lab=VDD}
N 12060 990 12090 990 {
lab=#net261}
N 12060 890 12090 890 {
lab=#net261}
N 12130 940 12130 960 {
lab=#net262}
N 12180 990 12180 1220 {
lab=GND}
N 12130 1020 12130 1140 {
lab=#net263}
N 12130 660 12130 740 {lab=VDD}
N 12090 740 12090 800 {lab=#net26}
N 12090 1100 12090 1170 {lab=VCtrl}
N 12130 770 12130 860 {lab=#net264}
N 12130 1170 12130 1220 {lab=GND}
N 12180 660 12180 890 {lab=VDD}
N 12130 660 12180 660 {lab=VDD}
N 12130 1220 12180 1220 {lab=GND}
N 11880 660 12130 660 {lab=VDD}
N 12060 940 12060 990 {lab=#net261}
N 11880 940 12060 940 {lab=#net261}
N 12060 890 12060 940 {lab=#net261}
N 11880 920 11880 940 {
lab=#net261}
N 11660 800 12090 800 {lab=#net26}
N 11660 1100 12090 1100 {lab=VCtrl}
N 11440 920 11440 940 {
lab=#net257}
N 11440 1220 11700 1220 {lab=GND}
N 11310 1220 11440 1220 {lab=GND}
N 11220 1100 11660 1100 {lab=VCtrl}
N 11220 800 11660 800 {lab=#net26}
N 11440 660 11700 660 {lab=VDD}
N 11010 990 11010 1220 {lab=GND}
N 10880 1220 11010 1220 {lab=GND}
N 11880 990 11880 1220 {lab=GND}
N 11750 1220 11880 1220 {lab=GND}
N 12240 990 12270 990 {
lab=#net262}
N 12240 890 12270 890 {
lab=#net262}
N 12240 940 12240 990 {
lab=#net262}
N 12130 940 12240 940 {
lab=#net262}
N 12240 890 12240 940 {
lab=#net262}
N 12180 660 12310 660 {lab=VDD}
N 12310 660 12310 890 {lab=VDD}
N 12310 940 12310 960 {
lab=delaycheckout}
N 12310 1220 12560 1220 {lab=GND}
N 12310 660 12560 660 {lab=VDD}
N 12310 940 12490 940 {lab=delaycheckout}
N 12310 920 12310 940 {
lab=delaycheckout}
N 12090 800 12520 800 {lab=#net26}
N 12090 1100 12520 1100 {lab=VCtrl}
N 12310 990 12310 1220 {lab=GND}
N 12180 1220 12310 1220 {lab=GND}
N 12130 920 12130 940 {
lab=#net262}
N 10560 1220 10830 1220 {lab=GND}
N 10560 660 10830 660 {lab=VDD}
N 10560 940 10760 940 {lab=#net249}
N 10340 800 10790 800 {lab=#net26}
N 10340 1100 10790 1100 {lab=VCtrl}
N -410 1220 -360 1220 {lab=GND}
N -880 800 -450 800 {lab=#net26}
N -880 1100 -450 1100 {lab=VCtrl}
N -410 660 -360 660 {lab=VDD}
N -2050 660 -1920 660 {lab=VDD}
N -410 940 -310 940 {lab=#net38}
N -410 920 -410 940 {
lab=#net38}
N -310 890 -310 940 {
lab=#net38}
C {code_shown.sym} 10 -960 0 0 {name=MODEL only_toplevel=false format="tcleval( @value )"

value="
  .lib $::MODELS_NGSPICE/cornerCAP.lib cap_typ
  .lib cornerMOSlv.lib mos_tt
  .lib cornerRES.lib res_typ
"



}
C {devices/lab_pin.sym} 12480 30 2 0 {name=p1 sig_type=std_logic lab=out}
C {lab_pin.sym} -2050 -250 0 0 {name=p2 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -1730 80 0 0 {name=M4
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -1730 260 0 0 {name=M5
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {devices/ammeter.sym} -1920 -20 0 0 {name=Vmycc
l=0.2u}
C {sg13g2_pr/sg13_lv_pmos.sym} -1730 -170 0 0 {name=M2
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1940 -170 0 0 {name=M14
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -1550 80 0 0 {name=M7
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -1940 260 0 0 {name=M21
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1730 -20 0 0 {name=M3
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1550 -20 0 0 {name=M6
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {code_shown.sym} 10 -810 0 0 {name=NGSPICE only_toplevel=true 
value="tcleval(
* Note! Since this script is wrapped in tcleval,
* code that is written in square brackets are in TCL scripting language
*
* The rest of the code is in spice scripting language

* Disabled because of computational cost/memory usage for big designs
* Save FET params like ids, gm, gds, vth, vgs, vdss, vds, cgg, cgsol, cgdol
* for annotation later (easier debugging and analysis)
* .include [file rootname [file tail [xschem get current_name]]].save

* Customized code to include spice model for simulation
.include sg13g2_stdcell.spice

.control
  save all  	
  tran 50p 2000n

  write [file rootname [file tail [xschem get current_name]]].raw

  * I DID NOT USE THE BELOW, because if an error occured we wouldn't know
  * Automatically close the popup after simulation complete *
  * quit
.endc
)"}
C {devices/vsource.sym} -2290 -390 0 0 {name=V2 value="PWL(0ns 0 1ns 1.2)"}
C {gnd.sym} -2290 -360 0 0 {name=l2 lab=GND}
C {lab_pin.sym} -2290 -420 2 0 {name=p13 lab=VDD}
C {devices/vsource.sym} -1970 80 0 0 {name=V1 value="PULSE(0 1.2 5n 100p 100p 10ns 20ns)"}
C {devices/lab_pin.sym} -1840 30 2 0 {name=p3 sig_type=std_logic lab=in}
C {gnd.sym} -1970 110 0 0 {name=l1 lab=GND}
C {gnd.sym} -1660 310 0 0 {name=l3 lab=GND}
C {lab_pin.sym} -2300 -300 0 0 {name=p4 lab=VSS}
C {res.sym} -2210 -330 0 0 {name=R1
value=0.00001
footprint=1206
device=resistor
m=1}
C {gnd.sym} -2290 320 0 0 {name=l4 lab=GND}
C {devices/launcher.sym} 60 -1020 0 0 {name=h1
descr="Ctrl + Left Click to Annotate and load waves" 
tclcommand="
xschem annotate_op
xschem raw_read $netlist_dir/[file rootname [file tail [xschem get current_name]]].raw tran
xschem setprop rect 2 0 fullxzoom
"
}
C {launcher.sym} 62.33626929682691 -1080 0 0 {name=h3
descr="Ctrl + Left Click to Simulate NGSPICE"
tclcommand="
# Setup the default simulation commands if not already set up
# for example by already launched simulations.
set_sim_defaults
puts $sim(spice,1,cmd) 

# Change the Xyce command. In the spice category there are currently
# 5 commands (0, 1, 2, 3, 4). Command 3 is the Xyce batch
# you can get the number by querying $sim(spice,n)
set sim(spice,1,cmd) \{ngspice  \\"$N\\" -a\}

# change the simulator to be used (Xyce)
set sim(spice,default) 0

# Create FET and BIP .save file
mkdir -p $netlist_dir
write_data [save_params] $netlist_dir/[file rootname [file tail [xschem get current_name]]].save

# Generate netlist
xschem netlist

# Run simulation
simulate

# While its nice to be able to wait for the simulation to complete,
# then automatically annotate and load waves,
# The following waits for the simulation popup to close,
# so if its not closed, then it will keep waiting

# set id1 [simulate]
# vwait execute(exitcode,$id1)
# put "done!"

"
}
C {sg13g2_pr/sg13_lv_nmos.sym} -1300 80 0 0 {name=M1
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -1300 260 0 0 {name=M8
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1300 -170 0 0 {name=M9
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -1120 80 0 0 {name=M10
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1300 -20 0 0 {name=M11
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1120 -20 0 0 {name=M12
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} -1230 310 0 0 {name=l5 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} -860 80 0 0 {name=M13
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -860 260 0 0 {name=M15
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -860 -170 0 0 {name=M16
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -680 80 0 0 {name=M17
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -860 -20 0 0 {name=M18
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -680 -20 0 0 {name=M19
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} -790 310 0 0 {name=l6 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} -430 80 0 0 {name=M20
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -430 260 0 0 {name=M22
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -430 -170 0 0 {name=M23
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -430 -20 0 0 {name=M25
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} -360 310 0 0 {name=l7 lab=GND}
C {lab_pin.sym} -2150 90 2 0 {name=p6 lab=VCtrl}
C {sg13g2_pr/sg13_lv_nmos.sym} -2310 160 0 0 {name=M27
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -2310 20 0 0 {name=M28
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -2330 160 0 0 {name=p7 lab=down}
C {lab_pin.sym} -2470 20 0 0 {name=p8 lab=up}
C {sg13g2_stdcells/sg13g2_inv_1.sym} -2430 20 0 0 {name=x7 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {isource.sym} -2540 220 0 0 {name=Il1 value=1u}
C {lab_pin.sym} -2290 -150 0 0 {name=p9 lab=VDD}
C {capa.sym} -2190 120 0 0 {name=C1
m=1
value=2p
footprint=1206
device="ceramic capacitor"}
C {gnd.sym} -2190 150 0 0 {name=l8 lab=GND}
C {sg13g2_stdcells/sg13g2_dfrbp_1.sym} -2910 10 0 0 {name=x53 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_dfrbp_1.sym} -2910 170 2 1 {name=x1 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} -3000 10 0 0 {name=p11 lab=VDD}
C {lab_pin.sym} -3000 170 0 0 {name=p14 lab=VDD}
C {lab_pin.sym} -2650 -10 2 0 {name=p10 lab=up}
C {lab_pin.sym} -2650 190 2 0 {name=p12 lab=down}
C {devices/lab_pin.sym} -3000 -10 0 0 {name=p15 sig_type=std_logic lab=in}
C {devices/lab_pin.sym} -3000 190 0 0 {name=p16 sig_type=std_logic lab=out}
C {sg13g2_pr/sg13_lv_pmos.sym} -2310 -100 0 0 {name=M29
l=0.4u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -2310 290 0 0 {name=M30
l=0.4u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -2560 290 0 0 {name=M31
l=0.4u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_pin.sym} -2540 190 0 0 {name=p17 lab=VDD}
C {sg13g2_pr/sg13_lv_pmos.sym} -2530 -90 0 0 {name=M32
l=0.4u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {isource.sym} -2510 -30 0 0 {name=Il2 value=1u}
C {gnd.sym} -2510 0 0 0 {name=l9 lab=GND}
C {sg13g2_stdcells/sg13g2_nand2_1.sym} -2710 90 2 0 {name=x23 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {devices/lab_pin.sym} 12480 940 2 0 {name=p18 sig_type=std_logic lab=delaycheckout}
C {lab_pin.sym} -2050 660 0 0 {name=p19 lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} -1730 990 0 0 {name=M33
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -1730 1170 0 0 {name=M34
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {devices/ammeter.sym} -1920 890 0 0 {name=Vmycc1
l=0.2u}
C {sg13g2_pr/sg13_lv_pmos.sym} -1730 740 0 0 {name=M35
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1940 740 0 0 {name=M36
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -1550 990 0 0 {name=M37
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -1940 1170 0 0 {name=M38
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1730 890 0 0 {name=M39
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1550 890 0 0 {name=M40
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {devices/vsource.sym} -1970 990 0 0 {name=V3 value="PULSE(0 1.2 5n 100p 100p 100ns 200ns)"}
C {gnd.sym} -1970 1020 0 0 {name=l10 lab=GND}
C {gnd.sym} -1660 1220 0 0 {name=l11 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} -1300 990 0 0 {name=M41
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -1300 1170 0 0 {name=M42
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1300 740 0 0 {name=M43
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -1120 990 0 0 {name=M44
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1300 890 0 0 {name=M45
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1120 890 0 0 {name=M46
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} -1230 1220 0 0 {name=l12 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} -860 990 0 0 {name=M47
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -860 1170 0 0 {name=M48
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -860 740 0 0 {name=M49
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -680 990 0 0 {name=M50
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -860 890 0 0 {name=M51
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -680 890 0 0 {name=M52
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} -790 1220 0 0 {name=l13 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} -430 990 0 0 {name=M53
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -430 1170 0 0 {name=M54
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -430 740 0 0 {name=M55
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -430 890 0 0 {name=M57
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} -360 1220 0 0 {name=l14 lab=GND}
C {devices/lab_pin.sym} -1900 940 2 0 {name=p20 sig_type=std_logic lab=delaycheckin}
C {sg13g2_pr/sg13_lv_nmos.sym} -250 80 0 0 {name=M59
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -250 -20 0 0 {name=M60
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 40 80 0 0 {name=M61
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 40 260 0 0 {name=M62
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 40 -170 0 0 {name=M63
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 220 80 0 0 {name=M64
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 40 -20 0 0 {name=M65
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 220 -20 0 0 {name=M66
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 110 310 0 0 {name=l15 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 470 80 0 0 {name=M67
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 470 260 0 0 {name=M68
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 470 -170 0 0 {name=M69
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 650 80 0 0 {name=M70
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 470 -20 0 0 {name=M71
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 650 -20 0 0 {name=M72
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 540 310 0 0 {name=l16 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 910 80 0 0 {name=M73
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 910 260 0 0 {name=M74
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 910 -170 0 0 {name=M75
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1090 80 0 0 {name=M76
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 910 -20 0 0 {name=M77
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1090 -20 0 0 {name=M78
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 980 310 0 0 {name=l17 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 1340 80 0 0 {name=M79
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1340 260 0 0 {name=M80
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1340 -170 0 0 {name=M81
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1340 -20 0 0 {name=M82
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 1410 310 0 0 {name=l18 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 1520 80 0 0 {name=M83
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1520 -20 0 0 {name=M84
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1870 80 0 0 {name=M85
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1870 260 0 0 {name=M86
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1870 -170 0 0 {name=M87
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2050 80 0 0 {name=M88
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1870 -20 0 0 {name=M89
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2050 -20 0 0 {name=M90
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 1940 310 0 0 {name=l19 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 2300 80 0 0 {name=M91
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2300 260 0 0 {name=M92
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2300 -170 0 0 {name=M93
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2480 80 0 0 {name=M94
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2300 -20 0 0 {name=M95
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2480 -20 0 0 {name=M96
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 2370 310 0 0 {name=l20 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 2740 80 0 0 {name=M97
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2740 260 0 0 {name=M98
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2740 -170 0 0 {name=M99
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2920 80 0 0 {name=M100
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2740 -20 0 0 {name=M101
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2920 -20 0 0 {name=M102
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 2810 310 0 0 {name=l21 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 3170 80 0 0 {name=M103
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3170 260 0 0 {name=M104
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3170 -170 0 0 {name=M105
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3170 -20 0 0 {name=M106
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 3240 310 0 0 {name=l22 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 3350 80 0 0 {name=M107
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3350 -20 0 0 {name=M108
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3690 80 0 0 {name=M109
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3690 260 0 0 {name=M110
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3690 -170 0 0 {name=M111
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3870 80 0 0 {name=M112
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3690 -20 0 0 {name=M113
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3870 -20 0 0 {name=M114
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 3760 310 0 0 {name=l23 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 4120 80 0 0 {name=M115
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4120 260 0 0 {name=M116
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4120 -170 0 0 {name=M117
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4300 80 0 0 {name=M118
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4120 -20 0 0 {name=M119
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4300 -20 0 0 {name=M120
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 4190 310 0 0 {name=l24 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 4560 80 0 0 {name=M121
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4560 260 0 0 {name=M122
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4560 -170 0 0 {name=M123
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4740 80 0 0 {name=M124
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4560 -20 0 0 {name=M125
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4740 -20 0 0 {name=M126
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 4630 310 0 0 {name=l25 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 4990 80 0 0 {name=M127
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4990 260 0 0 {name=M128
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4990 -170 0 0 {name=M129
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4990 -20 0 0 {name=M130
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 5060 310 0 0 {name=l26 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 5170 80 0 0 {name=M131
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 5170 -20 0 0 {name=M132
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 5510 80 0 0 {name=M133
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 5510 260 0 0 {name=M134
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 5510 -170 0 0 {name=M135
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 5690 80 0 0 {name=M136
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 5510 -20 0 0 {name=M137
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 5690 -20 0 0 {name=M138
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 5580 310 0 0 {name=l27 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 5940 80 0 0 {name=M139
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 5940 260 0 0 {name=M140
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 5940 -170 0 0 {name=M141
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 6120 80 0 0 {name=M142
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 5940 -20 0 0 {name=M143
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6120 -20 0 0 {name=M144
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 6010 310 0 0 {name=l28 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 6380 80 0 0 {name=M145
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 6380 260 0 0 {name=M146
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6380 -170 0 0 {name=M147
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 6560 80 0 0 {name=M148
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6380 -20 0 0 {name=M149
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6560 -20 0 0 {name=M150
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 6450 310 0 0 {name=l29 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 6810 80 0 0 {name=M151
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 6810 260 0 0 {name=M152
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6810 -170 0 0 {name=M153
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6810 -20 0 0 {name=M154
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 6880 310 0 0 {name=l30 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 6990 80 0 0 {name=M155
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6990 -20 0 0 {name=M156
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 7310 80 0 0 {name=M157
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 7310 260 0 0 {name=M158
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7310 -170 0 0 {name=M159
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 7490 80 0 0 {name=M160
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7310 -20 0 0 {name=M161
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7490 -20 0 0 {name=M162
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 7380 310 0 0 {name=l31 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 7740 80 0 0 {name=M163
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 7740 260 0 0 {name=M164
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7740 -170 0 0 {name=M165
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 7920 80 0 0 {name=M166
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7740 -20 0 0 {name=M167
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7920 -20 0 0 {name=M168
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 7810 310 0 0 {name=l32 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 8180 80 0 0 {name=M169
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 8180 260 0 0 {name=M170
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8180 -170 0 0 {name=M171
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 8360 80 0 0 {name=M172
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8180 -20 0 0 {name=M173
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8360 -20 0 0 {name=M174
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 8250 310 0 0 {name=l33 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 8610 80 0 0 {name=M175
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 8610 260 0 0 {name=M176
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8610 -170 0 0 {name=M177
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8610 -20 0 0 {name=M178
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 8680 310 0 0 {name=l34 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 8790 80 0 0 {name=M179
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8790 -20 0 0 {name=M180
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 9070 80 0 0 {name=M181
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 9070 260 0 0 {name=M182
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9070 -170 0 0 {name=M183
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 9250 80 0 0 {name=M184
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9070 -20 0 0 {name=M185
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9250 -20 0 0 {name=M186
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 9140 310 0 0 {name=l35 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 9500 80 0 0 {name=M187
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 9500 260 0 0 {name=M188
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9500 -170 0 0 {name=M189
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 9680 80 0 0 {name=M190
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9500 -20 0 0 {name=M191
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9680 -20 0 0 {name=M192
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 9570 310 0 0 {name=l36 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 9940 80 0 0 {name=M193
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 9940 260 0 0 {name=M194
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9940 -170 0 0 {name=M195
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 10120 80 0 0 {name=M196
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9940 -20 0 0 {name=M197
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10120 -20 0 0 {name=M198
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 10010 310 0 0 {name=l37 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 10370 80 0 0 {name=M199
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 10370 260 0 0 {name=M200
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10370 -170 0 0 {name=M201
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10370 -20 0 0 {name=M202
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 10440 310 0 0 {name=l38 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 10550 80 0 0 {name=M203
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10550 -20 0 0 {name=M204
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 10820 80 0 0 {name=M205
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 10820 260 0 0 {name=M206
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10820 -170 0 0 {name=M207
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 11000 80 0 0 {name=M208
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10820 -20 0 0 {name=M209
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11000 -20 0 0 {name=M210
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 10890 310 0 0 {name=l39 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 11250 80 0 0 {name=M211
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 11250 260 0 0 {name=M212
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11250 -170 0 0 {name=M213
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 11430 80 0 0 {name=M214
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11250 -20 0 0 {name=M215
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11430 -20 0 0 {name=M216
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 11320 310 0 0 {name=l40 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 11690 80 0 0 {name=M217
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 11690 260 0 0 {name=M218
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11690 -170 0 0 {name=M219
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 11870 80 0 0 {name=M220
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11690 -20 0 0 {name=M221
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11870 -20 0 0 {name=M222
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 11760 310 0 0 {name=l41 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 12120 80 0 0 {name=M223
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 12120 260 0 0 {name=M224
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 12120 -170 0 0 {name=M225
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 12120 -20 0 0 {name=M226
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 12190 310 0 0 {name=l42 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 12300 80 0 0 {name=M227
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 12300 -20 0 0 {name=M228
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -260 990 0 0 {name=M229
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -260 890 0 0 {name=M230
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 30 990 0 0 {name=M231
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 30 1170 0 0 {name=M232
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 30 740 0 0 {name=M233
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 210 990 0 0 {name=M234
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 30 890 0 0 {name=M235
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 210 890 0 0 {name=M236
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 100 1220 0 0 {name=l43 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 460 990 0 0 {name=M237
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 460 1170 0 0 {name=M238
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 460 740 0 0 {name=M239
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 640 990 0 0 {name=M240
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 460 890 0 0 {name=M241
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 640 890 0 0 {name=M242
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 530 1220 0 0 {name=l44 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 900 990 0 0 {name=M243
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 900 1170 0 0 {name=M244
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 900 740 0 0 {name=M245
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1080 990 0 0 {name=M246
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 900 890 0 0 {name=M247
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1080 890 0 0 {name=M248
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 970 1220 0 0 {name=l45 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 1330 990 0 0 {name=M249
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1330 1170 0 0 {name=M250
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1330 740 0 0 {name=M251
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1330 890 0 0 {name=M252
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 1400 1220 0 0 {name=l46 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 1510 990 0 0 {name=M253
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1510 890 0 0 {name=M254
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1860 990 0 0 {name=M255
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1860 1170 0 0 {name=M256
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1860 740 0 0 {name=M257
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2040 990 0 0 {name=M258
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1860 890 0 0 {name=M259
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2040 890 0 0 {name=M260
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 1930 1220 0 0 {name=l47 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 2290 990 0 0 {name=M261
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2290 1170 0 0 {name=M262
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2290 740 0 0 {name=M263
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2470 990 0 0 {name=M264
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2290 890 0 0 {name=M265
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2470 890 0 0 {name=M266
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 2360 1220 0 0 {name=l48 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 2730 990 0 0 {name=M267
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2730 1170 0 0 {name=M268
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2730 740 0 0 {name=M269
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2910 990 0 0 {name=M270
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2730 890 0 0 {name=M271
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2910 890 0 0 {name=M272
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 2800 1220 0 0 {name=l49 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 3160 990 0 0 {name=M273
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3160 1170 0 0 {name=M274
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3160 740 0 0 {name=M275
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3160 890 0 0 {name=M276
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 3230 1220 0 0 {name=l50 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 3340 990 0 0 {name=M277
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3340 890 0 0 {name=M278
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3680 990 0 0 {name=M279
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3680 1170 0 0 {name=M280
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3680 740 0 0 {name=M281
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3860 990 0 0 {name=M282
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3680 890 0 0 {name=M283
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3860 890 0 0 {name=M284
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 3750 1220 0 0 {name=l51 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 4110 990 0 0 {name=M285
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4110 1170 0 0 {name=M286
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4110 740 0 0 {name=M287
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4290 990 0 0 {name=M288
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4110 890 0 0 {name=M289
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4290 890 0 0 {name=M290
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 4180 1220 0 0 {name=l52 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 4550 990 0 0 {name=M291
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4550 1170 0 0 {name=M292
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4550 740 0 0 {name=M293
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4730 990 0 0 {name=M294
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4550 890 0 0 {name=M295
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4730 890 0 0 {name=M296
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 4620 1220 0 0 {name=l53 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 4980 990 0 0 {name=M297
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4980 1170 0 0 {name=M298
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4980 740 0 0 {name=M299
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4980 890 0 0 {name=M300
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 5050 1220 0 0 {name=l54 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 5160 990 0 0 {name=M301
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 5160 890 0 0 {name=M302
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 5500 990 0 0 {name=M303
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 5500 1170 0 0 {name=M304
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 5500 740 0 0 {name=M305
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 5680 990 0 0 {name=M306
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 5500 890 0 0 {name=M307
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 5680 890 0 0 {name=M308
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 5570 1220 0 0 {name=l55 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 5930 990 0 0 {name=M309
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 5930 1170 0 0 {name=M310
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 5930 740 0 0 {name=M311
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 6110 990 0 0 {name=M312
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 5930 890 0 0 {name=M313
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6110 890 0 0 {name=M314
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 6000 1220 0 0 {name=l56 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 6370 990 0 0 {name=M315
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 6370 1170 0 0 {name=M316
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6370 740 0 0 {name=M317
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 6550 990 0 0 {name=M318
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6370 890 0 0 {name=M319
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6550 890 0 0 {name=M320
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 6440 1220 0 0 {name=l57 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 6800 990 0 0 {name=M321
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 6800 1170 0 0 {name=M322
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6800 740 0 0 {name=M323
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6800 890 0 0 {name=M324
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 6870 1220 0 0 {name=l58 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 6980 990 0 0 {name=M325
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6980 890 0 0 {name=M326
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 7300 990 0 0 {name=M327
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 7300 1170 0 0 {name=M328
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7300 740 0 0 {name=M329
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 7480 990 0 0 {name=M330
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7300 890 0 0 {name=M331
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7480 890 0 0 {name=M332
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 7370 1220 0 0 {name=l59 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 7730 990 0 0 {name=M333
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 7730 1170 0 0 {name=M334
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7730 740 0 0 {name=M335
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 7910 990 0 0 {name=M336
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7730 890 0 0 {name=M337
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7910 890 0 0 {name=M338
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 7800 1220 0 0 {name=l60 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 8170 990 0 0 {name=M339
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 8170 1170 0 0 {name=M340
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8170 740 0 0 {name=M341
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 8350 990 0 0 {name=M342
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8170 890 0 0 {name=M343
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8350 890 0 0 {name=M344
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 8240 1220 0 0 {name=l61 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 8600 990 0 0 {name=M345
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 8600 1170 0 0 {name=M346
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8600 740 0 0 {name=M347
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8600 890 0 0 {name=M348
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 8670 1220 0 0 {name=l62 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 8780 990 0 0 {name=M349
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8780 890 0 0 {name=M350
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 9060 990 0 0 {name=M351
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 9060 1170 0 0 {name=M352
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9060 740 0 0 {name=M353
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 9240 990 0 0 {name=M354
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9060 890 0 0 {name=M355
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9240 890 0 0 {name=M356
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 9130 1220 0 0 {name=l63 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 9490 990 0 0 {name=M357
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 9490 1170 0 0 {name=M358
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9490 740 0 0 {name=M359
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 9670 990 0 0 {name=M360
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9490 890 0 0 {name=M361
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9670 890 0 0 {name=M362
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 9560 1220 0 0 {name=l64 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 9930 990 0 0 {name=M363
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 9930 1170 0 0 {name=M364
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9930 740 0 0 {name=M365
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 10110 990 0 0 {name=M366
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9930 890 0 0 {name=M367
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10110 890 0 0 {name=M368
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 10000 1220 0 0 {name=l65 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 10360 990 0 0 {name=M369
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 10360 1170 0 0 {name=M370
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10360 740 0 0 {name=M371
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10360 890 0 0 {name=M372
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 10430 1220 0 0 {name=l66 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 10540 990 0 0 {name=M373
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10540 890 0 0 {name=M374
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 10810 990 0 0 {name=M375
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 10810 1170 0 0 {name=M376
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10810 740 0 0 {name=M377
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 10990 990 0 0 {name=M378
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10810 890 0 0 {name=M379
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10990 890 0 0 {name=M380
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 10880 1220 0 0 {name=l67 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 11240 990 0 0 {name=M381
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 11240 1170 0 0 {name=M382
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11240 740 0 0 {name=M383
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 11420 990 0 0 {name=M384
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11240 890 0 0 {name=M385
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11420 890 0 0 {name=M386
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 11310 1220 0 0 {name=l68 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 11680 990 0 0 {name=M387
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 11680 1170 0 0 {name=M388
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11680 740 0 0 {name=M389
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 11860 990 0 0 {name=M390
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11680 890 0 0 {name=M391
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11860 890 0 0 {name=M392
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 11750 1220 0 0 {name=l69 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 12110 990 0 0 {name=M393
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 12110 1170 0 0 {name=M394
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 12110 740 0 0 {name=M395
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 12110 890 0 0 {name=M396
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {gnd.sym} 12180 1220 0 0 {name=l70 lab=GND}
C {sg13g2_pr/sg13_lv_nmos.sym} 12290 990 0 0 {name=M397
l=0.2u
w=0.74u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 12290 890 0 0 {name=M398
l=0.2u
w=1.12u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} -2040 260 2 0 {name=p5 lab=VCtrl}
C {lab_pin.sym} -2040 1170 2 0 {name=p21 lab=VCtrl}
