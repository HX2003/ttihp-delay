** sch_path: archive/bias_gen_res.sch
**.subckt bias_gen_res
V2 VDD GND PWL(0ns 0 5ns 1.2)
XM4002 net1 net3 VDD VDD sg13_lv_pmos w=4u l=1u ng=2 m=2 mm_ok=1
XM4007 net2 net1 GND GND sg13_lv_nmos w=4u l=1u ng=2 m=2 mm_ok=1
Vcurmain net4 net2 0
.save i(vcurmain)
XM4006 net1 net1 GND GND sg13_lv_nmos w=4u l=1u ng=2 m=2 mm_ok=1
XM4003 net4 net3 VDD VDD sg13_lv_pmos w=4u l=1u ng=2 m=2 mm_ok=1
Vmcur2 net3 node1 0
.save i(vmcur2)
XM4000 net5 net3 VDD VDD sg13_lv_pmos w=4u l=1u ng=2 m=2 mm_ok=1
XM4001 net3 net3 VDD VDD sg13_lv_pmos w=4u l=1u ng=2 m=2 mm_ok=1
Vmcur net5 node0 0
.save i(vmcur)
XM4004 node0 node0 GND GND sg13_lv_nmos w=4u l=1u ng=2 m=1 mm_ok=1
XM4005 node1 node0 net6 GND sg13_lv_nmos w=4u l=1u ng=2 m=4 mm_ok=1
XR4 net6 net8 sub! rppd w=1e-6 l=16e-6 m=1 b=0 mm_ok=1
XM4102 net7 net7 VDD VDD sg13_lv_pmos w=0.36u l=2u ng=1 m=1 mm_ok=1
XM4100 node1 net7 node0 GND sg13_lv_nmos w=4u l=1u ng=2 m=1 mm_ok=1
XM4101 net7 node0 GND GND sg13_lv_nmos w=4u l=1u ng=2 m=4 mm_ok=1
XR1 net8 GND sub! rppd w=1e-6 l=16e-6 m=1 b=0 mm_ok=1
XR2 GND sub! ptap1 R=262.8 w=0.78e-6 l=0.78e-6
**** begin user architecture code

  .lib $::MODELS_NGSPICE/cornerCAP.lib cap_typ
  .lib cornerMOSlv.lib mos_tt
  .lib cornerRES.lib res_typ



* Note! Since this script is wrapped in tcleval,
* code that is written in square brackets are in TCL scripting language
*
* The rest of the code is in spice scripting language

* Disabled because of computational cost/memory usage for big designs
* Save FET params like ids, gm, gds, vth, vgs, vdss, vds, cgg, cgsol, cgdol
* for annotation later (easier debugging and analysis)
.include [file rootname [file tail [xschem get current_name]]].save

* Customized code to include spice model for simulation

.include sg13g2_stdcell.spice
.options temp=25

* For a 'Beta Multiplier' circuit,
* zero current is a possible steady-state operating point,
* so lets force this initial condition, and see if start-up circuit
* works. (Without start-up circuit, the current stays at zero as expected)
.ic v(node0)=0
.ic v(node1)=1.2

.control
  save all

  * Initialize all nodes to 0V, except for node1
  tran 5p 100n uic

  write [file rootname [file tail [xschem get current_name]]].raw

  * I DID NOT USE THE BELOW, because if an error occured we wouldn't know
  * Automatically close the popup after simulation complete *
  * quit
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL sub!
.end
