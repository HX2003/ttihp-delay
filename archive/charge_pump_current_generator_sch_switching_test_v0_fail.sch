** sch_path: archive/charge_pump_current_generator_sch_switching_test_v0_fail.sch
**.subckt charge_pump_current_generator_sch_switching_test_v0_fail
V2 VDD GND PWL(0ns 0 5ns 1.2)
V4 up GND PULSE(0 1.2 0n 100p 100p 5ns 20ns)
x7 net1 up VDD VSS sg13g2_inv_1
Vchargeup net11 net2 0
.save i(vchargeup)
Vchargedown net2 net12 0
.save i(vchargedown)
Vcharge net2 cap 0
.save i(vcharge)
C1 cap GND 10p m=1
V1 down GND PULSE(0 1.2 10n 100p 100p 5ns 20ns)
XM4002 net5 node1 VDD VDD sg13_lv_pmos w=4u l=1u ng=2 m=2 mm_ok=1
XM4007 net6 VDD GND GND sg13_lv_nmos w=2u l=1u ng=2 m=1 mm_ok=1
XM4006 net7 VDD GND GND sg13_lv_nmos w=2u l=1u ng=2 m=1 mm_ok=1
XM4000 node0 node1 VDD VDD sg13_lv_pmos w=4u l=1u ng=2 m=2 mm_ok=1
XM4001 node1 node1 VDD VDD sg13_lv_pmos w=4u l=1u ng=2 m=2 mm_ok=1
XM4004 node0 node0 GND GND sg13_lv_nmos w=4u l=1u ng=2 m=1 mm_ok=1
XM4005 node1 node0 net3 GND sg13_lv_nmos w=4u l=1u ng=2 m=4 mm_ok=1
XR2 net3 net14 sub! rppd w=1e-6 l=16e-6 m=1 b=0 mm_ok=1
XM4102 net4 net4 VDD VDD sg13_lv_pmos w=0.36u l=2u ng=1 m=1 mm_ok=1
XM4100 node1 net4 node0 GND sg13_lv_nmos w=4u l=1u ng=2 m=1 mm_ok=1
XM4101 net4 node0 GND GND sg13_lv_nmos w=4u l=1u ng=2 m=4 mm_ok=1
XR1 net14 GND sub! rppd w=1e-6 l=16e-6 m=1 b=0 mm_ok=1
XR4 GND sub! ptap1 R=262.8 w=0.78e-6 l=0.78e-6
XM4008 net5 net5 net7 GND sg13_lv_nmos w=4u l=1u ng=2 m=2 mm_ok=1
XM4009 net8 net5 net6 GND sg13_lv_nmos w=4u l=1u ng=2 m=2 mm_ok=1
XM1 net13 down GND GND sg13_lv_nmos w=2u l=1u ng=2 m=1 mm_ok=1
XM2 net12 net5 net13 GND sg13_lv_nmos w=4u l=1u ng=2 m=2 mm_ok=1
XM3 net8 net8 net9 VDD sg13_lv_pmos w=4u l=1u ng=2 m=2 mm_ok=1
XM4 net11 net8 net10 VDD sg13_lv_pmos w=4u l=1u ng=2 m=2 mm_ok=1
XM5 net9 GND VDD VDD sg13_lv_pmos w=2u l=1u ng=2 m=1 mm_ok=1
XM6 net10 net1 VDD VDD sg13_lv_pmos w=2u l=1u ng=2 m=1 mm_ok=1
R3 GND VSS 0.00001 m=1
XM7 VDD down net15 VDD sg13_lv_pmos w=2u l=1u ng=2 m=1 mm_ok=1
XM8 net10 up net10 VDD sg13_lv_pmos w=2u l=1u ng=2 m=1 mm_ok=1
**** begin user architecture code

  .lib $::MODELS_NGSPICE/cornerCAP.lib cap_typ
  .lib cornerMOSlv.lib mos_tt
  .lib cornerRES.lib res_typ



* Note! Since this script is wrapped in tcleval,
* code that is written in square brackets are in TCL scripting language
*
* The rest of the code is in spice scripting language

* Disabled because of computational cost/memory usage for big designs
* Save FET params like ids, gm, gds, vth, vgs, vdss, vds, cgg, cgsol, cgdol
* for annotation later (easier debugging and analysis)
.include [file rootname [file tail [xschem get current_name]]].save

* Customized code to include spice model for simulation

.include sg13g2_stdcell.spice
.options temp=25

* For a 'Beta Multiplier' circuit,
* zero current is a possible steady-state operating point,
* so lets force this initial condition, and see if start-up circuit
* works. (Without start-up circuit, the current stays at zero as expected)
.ic v(x1.node0)=0
.ic v(x1.node1)=1.2

* Make capacitor 0.6V
.ic v(cap)=0.6

.control
  save all

  * Initialize all nodes to 0V, except for node1
  tran 2p 100n uic

  write [file rootname [file tail [xschem get current_name]]].raw

  * I DID NOT USE THE BELOW, because if an error occured we wouldn't know
  * Automatically close the popup after simulation complete *
  * quit
.endc


**** end user architecture code
**.ends

* expanding   symbol:  sg13g2_stdcells/sg13g2_inv_1.sym # of pins=2
** sym_path: sg13g2_stdcells/sg13g2_inv_1.sym
** sch_path: sg13g2_stdcells/sg13g2_inv_1.sch
.subckt sg13g2_inv_1 Y A VDD VSS
*.opin Y
*.ipin A
*.iopin VDD
*.iopin VSS
XM1 Y A VSS VSS sg13_lv_nmos w=740.00n l=130.00n ng=1 m=1 mm_ok=1
XM2 Y A VDD VDD sg13_lv_pmos w=1.12u l=130.00n ng=1 m=1 mm_ok=1
.ends

.GLOBAL GND
.GLOBAL sub!
.end
