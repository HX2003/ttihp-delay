** sch_path: archive/bias_gen_other_version.sch
**.subckt bias_gen_other_version
Vdd VDD GND PWL(0ns 0 0.1ns 1.0)
XM4 vbiasn vbiasn GND GND sg13_lv_nmos w=9u l=0.5u ng=1 m=2 mm_ok=1
XM5 net4 vbiasp VDD VDD sg13_lv_pmos w=10u l=1u ng=1 m=8 mm_ok=1
XM6 vbiasp vbiasp VDD VDD sg13_lv_pmos w=10u l=1u ng=1 m=8 mm_ok=1
XM7 vref vbiasp VDD VDD sg13_lv_pmos w=10u l=1u ng=1 m=8 mm_ok=1
XM8 net3 vbiasn net1 GND sg13_lv_nmos w=7u l=0.5u ng=1 m=36 mm_ok=1
XM9 net1 vref GND GND sg13_lv_nmos w=1.42u l=0.88u ng=1 m=1 mm_ok=1
XM10 net2 vref net1 GND sg13_lv_nmos w=1.42u l=0.88u ng=1 m=1 mm_ok=1
XM11 vref vref net2 GND sg13_lv_nmos w=1.42u l=0.88u ng=1 m=1 mm_ok=1
Vmcur1 net4 vbiasn 0
.save i(vmcur1)
XM12 net5 vbiasp VDD VDD sg13_lv_pmos w=2u l=0.4u ng=1 m=1 mm_ok=1
XM13 net6 net5 GND GND sg13_lv_nmos w=2u l=0.4u ng=1 m=1 mm_ok=1
Vcurmain1 net7 net6 0
.save i(vcurmain1)
XM14 net5 net5 GND GND sg13_lv_nmos w=2u l=0.4u ng=1 m=1 mm_ok=1
XM16 net7 vbiasp VDD VDD sg13_lv_pmos w=2u l=0.4u ng=1 m=1 mm_ok=1
XM17 vbiasp vbiasn net3 GND sg13_lv_nmos w=10u l=0.13u ng=1 m=1 mm_ok=1
XM18 vbiasp vref net8 GND sg13_lv_nmos w=10u l=0.13u ng=1 m=1 mm_ok=1
XM19 vbiasn vref net8 VDD sg13_lv_pmos w=10u l=0.13u ng=1 m=8 mm_ok=1
**** begin user architecture code

  .lib $::MODELS_NGSPICE/cornerCAP.lib cap_typ
  .lib cornerMOSlv.lib mos_tt
  .lib cornerRES.lib res_typ



* Note! Since this script is wrapped in tcleval,
* code that is written in square brackets are in TCL scripting language
*
* The rest of the code is in spice scripting language

* Disabled because of computational cost/memory usage for big designs
* Save FET params like ids, gm, gds, vth, vgs, vdss, vds, cgg, cgsol, cgdol
* for annotation later (easier debugging and analysis)
.include [file rootname [file tail [xschem get current_name]]].save

* Customized code to include spice model for simulation
.include sg13g2_stdcell.spice

.control
  save all

  tran 5p 100n

  write [file rootname [file tail [xschem get current_name]]].raw

  * I DID NOT USE THE BELOW, because if an error occured we wouldn't know
  * Automatically close the popup after simulation complete *
  * quit
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
