** sch_path: archive/bias_gen_no_res.sch
**.subckt bias_gen_no_res
V2 VDD GND PWL(0ns 0 0.1ns 1.0)
Vmcur2 vbiasp net4 0
.save i(vmcur2)
XM15 vbiasn vbiasn GND GND sg13_lv_nmos w=2u l=0.4u ng=1 m=1 mm_ok=1
XM1 net5 vbiasp VDD VDD sg13_lv_pmos w=2u l=0.4u ng=1 m=1 mm_ok=1
XM33 vbiasp vbiasp VDD VDD sg13_lv_pmos w=2u l=0.4u ng=1 m=1 mm_ok=1
XM53 net3 vbiasp VDD VDD sg13_lv_pmos w=2u l=0.4u ng=1 m=1 mm_ok=1
XM55 net4 vbiasn net1 GND sg13_lv_nmos w=2u l=0.4u ng=1 m=8 mm_ok=1
XM56 net1 net3 GND GND sg13_lv_nmos w=0.8u l=2u ng=1 m=1 mm_ok=1
XM57 net2 net3 net1 GND sg13_lv_nmos w=0.4u l=1u ng=1 m=1 mm_ok=1
XM58 net3 net3 net2 GND sg13_lv_nmos w=0.4u l=1u ng=1 m=1 mm_ok=1
Vmcur net5 vbiasn 0
.save i(vmcur)
XM29 net6 vbiasp VDD VDD sg13_lv_pmos w=2u l=0.4u ng=1 m=1 mm_ok=1
XM30 net7 net6 GND GND sg13_lv_nmos w=2u l=0.4u ng=1 m=1 mm_ok=1
Vcurmain net8 net7 0
.save i(vcurmain)
XM2 net6 net6 GND GND sg13_lv_nmos w=2u l=0.4u ng=1 m=1 mm_ok=1
XM3 net8 vbiasp VDD VDD sg13_lv_pmos w=2u l=0.4u ng=1 m=1 mm_ok=1
**** begin user architecture code

  .lib $::MODELS_NGSPICE/cornerCAP.lib cap_typ
  .lib cornerMOSlv.lib mos_tt
  .lib cornerRES.lib res_typ



* Note! Since this script is wrapped in tcleval,
* code that is written in square brackets are in TCL scripting language
*
* The rest of the code is in spice scripting language

* Disabled because of computational cost/memory usage for big designs
* Save FET params like ids, gm, gds, vth, vgs, vdss, vds, cgg, cgsol, cgdol
* for annotation later (easier debugging and analysis)
.include [file rootname [file tail [xschem get current_name]]].save

* Customized code to include spice model for simulation
.include sg13g2_stdcell.spice

.control
  save all

  tran 5p 100n

  write [file rootname [file tail [xschem get current_name]]].raw

  * I DID NOT USE THE BELOW, because if an error occured we wouldn't know
  * Automatically close the popup after simulation complete *
  * quit
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
